Properties of the parts of a building model (IFC4), part 2 of 3

# IfcPipeFitting: RAUPIANO PLUS Bend:RPP (64)
Name (RAUPIANO PLUS Bend:RPP:...) | Sleeve = V. Sleeve 1 | Swept bend | Angle check (deg) = Angle (deg) | L1 (mm) | L connector 1 (mm) | L connector 2 (mm) = Z1 (mm) | Swept | Z2 (mm) | DN 1 (mm) = Maximum Size (mm) = Minimum Size (mm) | Size = Overall Size | Volume (m3) | Use Annotation Scale | Description long | Description short | GTIN | PID | Weight
177281 | no | no | 45 | 85 | 128.078 | 43.0782 | 0 | 104 | 200 | 200 mmø-200 mmø | 0.00127178 |  | RAUPIANO PLUS Bend DN/OD 200, 45 degree |  | 4007360585150 | 11230971001 | 1404

# IfcPipeFitting: RAUPIANO PLUS Bend_For Gully:RPP, RAUPIANO PLUS Bend_For Gully:RPP:244766
In: Ground floor
Type - Material: RAUPIANO PLUS
Type - Other - Category: Pipe Fittings; Family Name: RAUPIANO PLUS Bend_For Gully; REH_LOOKUP_TABLE_NAME: REHAU_RAUPIANO PLUS Bend_DE
Type - Constraints - Default Elevation: 0.0131234 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; ETIM_CLASS: EC003024; ETIM_CLASS_CODE: MC000011; Manufacturer: REHAU; REH_BIM_SUPPORT: bim@rehau.com; REH_INFO: 2022.09.28-416508-416508; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-3896.jpg; Type Name: RPP; URL: www.rehau.com
Type - Materials and Finishes - REH_MATERIAL: RAUPIANO PLUS
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Description: RAUPIANO PLUS Bend
Pset_EnvironmentalImpactIndicators - Reference: RAUPIANO PLUS Bend_For Gully:RPP; sets with these values: 2
Other - IsCustom: no; Type: RPP; Family: RAUPIANO PLUS Bend_For Gully; Family and Type: RAUPIANO PLUS Bend_For Gully: RPP; Type Id: 244500
Constraints - Level: Ground floor; Moves With Nearby Elements: no; Elevation from Level: 5.58376 mm
Construction - REH_FLIP: no; REH_PIPE_SOCKET: yes; Nominal Diameter: 75 mm; REH_SWEPT_BEND: no
Dimensions - Angle: 45 deg; REH_ANGLE_CHECK: 45 deg; Area: 0.000517145 m2; DN1: 75 mm; DN2: 75 mm; Do1: 75.2 mm; Dr2: 89 mm; j2: 3.3 mm; L1: 69.6 mm; L2: 72.6 mm; P2: 51.6 mm; Q1: 51.6 mm; r: 43.4558 mm; t2: 11.2 mm; Volume: 0.0000764962 m3; Z1: 18 mm; Z2: 21 mm
Graphics - Use Annotation Scale: no
Identity Data - REH_DESCRIPTION_SHORT: RAUPIANO PLUS Bend; REH_GTIN: 4059757975990; REH_MANUFACTURER_PID: 11211641002; REH_NETWEIGHT_G/PC: 142; REH_NOMINAL_DIAMETER: DN 75/45°; REH_SUPPLIER_PID: 11211641002
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcPipeFitting: RAUPIANO PLUS Corner double branch:RPP (2)
In: Ground floor
Type - Material: RAUPIANO PLUS
Type - Other - Category: Pipe Fittings; Family Name: RAUPIANO PLUS Corner double branch; T1: RP Corner double branch; T2: RP Corner double branch DN1; T3: RP Pipe Size
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUPIANO PLUS; REHAU Info: 2024.08.14-419114-419114; Type Name: RPP; URL: www.rehau.com
Type - Materials and Finishes - REH_MATERIAL: RAUPIANO PLUS
Type - Mechanical - Loss Method: K Coefficient from Table; K Coefficient Table: Converging/Diverging Tee/Wye
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Description: RAUPIANO PLUS Corner double branch DN/OD 110/110/110, 87 degree
Pset_EnvironmentalImpactIndicators - Reference: RAUPIANO PLUS Corner double branch:RPP; sets with these values: 2
Other - IsCustom: no; Type: RPP; Family: RAUPIANO PLUS Corner double branch; Family and Type: RAUPIANO PLUS Corner double branch: RPP; Type Id: 24855
Constraints - Elevation from Level: 0 mm; Level: Ground floor
Construction - REH_PIPE_SOCKET: yes; REH_SLOPE: yes
Data - PID Check: 1 mm
Dimensions - Angle: 87 deg; REH_ANGLE_CHECK: 87 deg; Angle 2: 87 deg; Area: 0.000517145 m2; L1: 118 mm; Q2: 58 mm; Z5: 62.0851 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class code: EC003025
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUPIANO PLUS Corner double branch:RPP:...) | Nominal Diameter 1 (mm) = Nominal Diameter 2 (mm) = Nominal Diameter 3 (mm) = Nominal Diameter 4 (mm) = DN1 (mm) = DN2 (mm) = DN3 (mm) = DN4 (mm) = Maximum Size (mm) = Minimum Size (mm) | REH_MAX_FLOW | Do2 (mm) | Dr1 (mm) | Dr3 (mm) = Dr4 (mm) | j1 (mm) = j3 (mm) = j4 (mm) | L2 (mm) | L3 (mm) = L4 (mm) | P1 (mm) = P3 (mm) = P4 (mm) | r (mm) | Size = Overall Size | t1 (mm) = t3 (mm) = t4 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Z3 (mm) = Z4 (mm) | Description long | GTIN | PID | Weight
143019 | 110 | no | 110.2 | 126 | 126 | 3.6 | 115 | 118 | 56 | 65.3344 | 110 mmø-110 mmø-110 mmø-110 mmø | 13.9 | 0.000452008 | 62 | 57 | 62 | RAUPIANO PLUS Corner double branch DN/OD 110/110/110, 87 degree | 4007360550875 | 11215641003 | 717
143095 | 90 | yes | 90.2 | 52 | 104 | 3 | 114 | 122 | 52 | 73.7646 | 90 mmø-90 mmø-90 mmø-90 mmø | 12.5 | 0.000570875 | 66 | 56 | 70 | RAUPIANO PLUS Corner double branch DN/OD 90/90/90, 87 degree, max flow | 4059757620630 | 11237241003 | 488.76

# IfcPipeFitting: RAUPIANO PLUS Deflection Bend:RPP (6)
In: Ground floor
Type - Material: RAUPIANO PLUS
Type - Other - Category: Pipe Fittings; Family Name: RAUPIANO PLUS Deflection Bend; T1: RP Deflection Bend; T2: RPP
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Language Tender Text: Tender Text en; Region Check: Check DE; Region PID: PID DE; Region URL: Product URL DE
Type - Identity Data - Assembly Code: D2030100; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUPIANO PLUS; Type Name: RPP; URL: https://oxomi.com/p/3000126?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAfQAsACIAcQB1AGUAcgB5ACIAOgAiAFIAQQBVAFAASQBBAE4ATwAgAFAATABVAFMAIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA0ADUAMwA1ADMAMAAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAUABJAEEATgBPACAAUABMAFUAUwAiACwAIgBzAGkAbgBnAGwAZQBQAGEAZwBlACIAOgB0AHIAdQBlACwAIgBlAHgAdABlAHIAbgBhAGwATABpAG4AawBzAEUAbgBhAGIAbABlAGQAIgA6AHQAcgB1AGUALAAiAHAAYQBnAGUAIgA6ADEAfQB9AH0A
Type - Materials and Finishes - RPP: RAUPIANO PLUS
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2030100 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: RAUPIANO PLUS Deflection Bend:RPP; sets with these values: 2
Other - IsCustom: no; Type: RPP; Family: RAUPIANO PLUS Deflection Bend; Family and Type: RAUPIANO PLUS Deflection Bend: RPP; Type Id: 204680
Constraints - Elevation from Level: 0 mm; Level: Ground floor
Data - PID Check: 1 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class: EC003024; ETIM Group: EG015540; ETIM Name: Fitting with 2 connections; Tender text: -
Mechanical - System Classification: Undefined
Mechanical - Flow - Pressure Drop: 0 Pa
Phasing - Phase Created: New Construction
Visibility - Sleeve: yes
Insulation - Insulation Thickness: 0 mm
Name (RAUPIANO PLUS Deflection Bend:RPP:...) | Angle check (deg) = Angle (deg) | L1.1 (mm) | L2.1 (mm) | R1.1 (mm) | Area (m2) | Di1 (mm) | DN1 (mm) = Maximum Size (mm) = Minimum Size (mm) | s (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Product Group | Product URL | Weight
204731 | 45 | 16.7756 | 216.776 | 40.5 | 0.103243 | 71.2 | 75 | 1.9 | 75 mmø-75 mmø | 0.000183776 | RAUPIANO PLUS Deflection bend DN/OD 75, 45 degree | 4007360584320 | 11230561002 | 2817 | https://oxomi.com/p/3000126/datasheet/-/11230561002 | 0.37041
205069 | 45 | 19.8823 | 219.882 | 48 | 0.126307 | 85.6 | 90 | 2.2 | 90 mmø-90 mmø | 0.000262729 | RAUPIANO PLUS Deflection bend DN/OD 90, 45 degree, thickened wall | 4007360584481 | 11230571002 | 2818 | https://oxomi.com/p/3000126/datasheet/-/11230571002 | 0.44959
205078 | 45 | 24.0244 | 224.024 | 58 | 0.162709 | 104.6 | 110 | 2.7 | 110 mmø-110 mmø | 0.000418564 | RAUPIANO PLUS Deflection bend DN/OD 110, 45 degree, thickened wall | 4007360584337 | 11230581002 | 2819 | https://oxomi.com/p/3000126/datasheet/-/11230581002 | 0.93719
205289 | 87 | 38.4331 | 193.433 | 40.5 | 0.0997264 | 71.2 | 75 | 1.9 | 75 mmø-75 mmø | 0.000177096 | RAUPIANO PLUS Deflection bend DN/OD 75, 87 degree | 4007360584344 | 11230751002 | 2813 | https://oxomi.com/p/3000126/datasheet/-/11230751002 | 0.28
205291 | 87 | 45.5503 | 200.55 | 48 | 0.1236 | 85.6 | 90 | 2.2 | 90 mmø-90 mmø | 0.000256775 | RAUPIANO PLUS Deflection bend DN/OD 90, 87 degree, thickened wall | 4007360584351 | 11230851002 | 2814 | https://oxomi.com/p/3000126/datasheet/-/11230851002 | 0.50173
205293 | 87 | 55.0399 | 210.04 | 58 | 0.161872 | 104.6 | 110 | 2.7 | 110 mmø-110 mmø | 0.000416305 | RAUPIANO PLUS Deflection bend DN/OD 110, 87 degree, thickened wall | 4007360584368 | 11230951002 | 2815 | https://oxomi.com/p/3000126/datasheet/-/11230951002 | 1.108

# IfcPipeFitting: RAUPIANO PLUS Double branch:RPP (6)
In: Ground floor
Type - Material: RAUPIANO PLUS
Type - Other - Category: Pipe Fittings; Family Name: RAUPIANO PLUS Double branch; T1: RP Double branch; T2: RP Double branch DN1; T3: RP Pipe Size
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Manufacturer: REHAU; Model: RAUPIANO PLUS; REHAU Info: 2024.08.15-419114-419114; Type Name: RPP; URL: www.rehau.com
Type - Materials and Finishes - REH_MATERIAL: RAUPIANO PLUS
Type - Mechanical - Loss Method: K Coefficient from Table; K Coefficient Table: Converging/Diverging Tee/Wye
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUPIANO PLUS Double branch:RPP; sets with these values: 2
Other - IsCustom: no; Type: RPP; Family: RAUPIANO PLUS Double branch; Family and Type: RAUPIANO PLUS Double branch: RPP; Type Id: 20821
Constraints - Elevation from Level: 0 mm; Level: Ground floor
Construction - REH_PIPE_SOCKET: yes
Data - PID Check: 1 mm
Dimensions - Area: 0.000517145 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class code: EC003025
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUPIANO PLUS Double branch:RPP:...) | Description | REH_MAX_FLOW | Nominal Diameter 1 (mm) = Nominal Diameter 3 (mm) = DN1 (mm) = DN3 (mm) = Maximum Size (mm) | Nominal Diameter 2 (mm) = Nominal Diameter 4 (mm) = DN2 (mm) = DN4 (mm) = Minimum Size (mm) | Angle (deg) = REH_ANGLE_CHECK (deg) = Angle 2 (deg) = REH_ANGLE_CHECK2 (deg) | Do1 (mm) | Dr2 (mm) = Dr4 (mm) | Dr3 (mm) | j2 (mm) = j4 (mm) | j3 (mm) | L1 (mm) | L2 (mm) = L4 (mm) | L3 (mm) | P2 (mm) = P4 (mm) | P3 (mm) | Q1 (mm) | r (mm) | Size = Overall Size | t2 (mm) = t4 (mm) | t3 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) = Z4 (mm) | Z3 (mm) | Description long | GTIN | PID | Weight
150221 | RAUPIANO PLUS Double branch DN/OD 90/90/90, 87 degree, max flow | yes | 90 | 90 | 87 | 90.2 | 105 | 105 | 3 | 3 | 114 | 122 | 103 | 52 | 52 | 51 | 66.3881 | 90 mmø-90 mmø-90 mmø-90 mmø | 12.5 | 12.5 | 0.000673158 | 63 | 70 | 51 | RAUPIANO PLUS Double branch DN/OD 90/90/90, 87 degree, max flow | 4007360388454 | 11237141001 | 472
158509 | RAUPIANO PLUS Double branch DN/OD 110/110/110, 45 degree | yes | 110 | 110 | 87 | 110.2 | 127.4 | 127.4 | 3.6 | 3.6 | 120 | 111 | 118 | 49 | 56 | 63 | 60.0655 | 110 mmø-110 mmø-110 mmø-110 mmø | 13.9 | 13.9 | 0.000721458 | 57 | 62 | 62 | RAUPIANO PLUS Double branch DN/OD 110/110/110, 87 degree max flow | 4064299401241 | 11241191001 | 766
162739 | RAUPIANO PLUS Double branch DN/OD 110/110/110, 45 degree | no | 110 | 110 | 87 | 110.2 | 127.4 | 127.4 | 3.6 | 3.6 | 120 | 111 | 118 | 49 | 56 | 63 | 60.0655 | 110 mmø-110 mmø-110 mmø-110 mmø | 13.9 | 13.9 | 0.000596538 | 57 | 62 | 62 | RAUPIANO PLUS Double branch DN/OD 110/110/110, 87 degree | 4007360058562 | 11215541001 | 708
166983 | RAUPIANO PLUS Double branch DN/OD 110/110/110, 45 degree | no | 110 | 110 | 45 | 110.2 | 127.4 | 127.4 | 3.6 | 3.6 | 83 | 192 | 192 | 58 | 58 | 58 | 60.3553 | 110 mmø-110 mmø-110 mmø-110 mmø | 13.9 | 13.9 | 0.00078674 | 25 | 134 | 134 | RAUPIANO PLUS Double branch DN/OD 110/110/110, 45 degree | 4007360388225 | 11229641001 | 901
167199 | RAUPIANO PLUS Double branch DN/OD 125/110/110, 45 degree | no | 125 | 110 | 45 | 125.2 | 127.4 | 146 | 3.6 | 4.2 | 82 | 200 | 202 | 56 | 61 | 64 | 43.4558 | 125 mmø-125 mmø-110 mmø-110 mmø | 13.9 | 16 | 0.000966456 | 18 | 144 | 141 | RAUPIANO PLUS Double branch DN/OD 125/110/110, 45 degree | 4007360388249 | 11235941001 | 1040
167583 | RAUPIANO PLUS Double branch DN/OD 160/110/110, 87 degree | no | 160 | 110 | 87 | 160.2 | 127.4 | 184 | 3.6 | 5.5 | 154 | 142 | 156 | 56 | 92 | 96 | 61.1192 | 160 mmø-160 mmø-110 mmø-110 mmø | 13.9 | 18.4 | 0.00122331 | 58 | 86 | 64 | RAUPIANO PLUS Double branch DN/OD 160/110/110, 87 degree | 4007360388430 | 11236841001 | 1170

# IfcPipeFitting: RAUPIANO PLUS Double socket_For Gully:RPP (3)
In: Ground floor
Type - Material: RAUPIANO PLUS
Type - Other - Category: Pipe Fittings; Family Name: RAUPIANO PLUS Double socket_For Gully; REH_LOOKUP_TABLE_NAME: REHAU_RAUPIANO PLUS Double socket_DE
Type - Constraints - Default Elevation: 0.0131234 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; ETIM_CLASS: EC003024; ETIM_CLASS_CODE: MC000010; Manufacturer: REHAU; REH_INFO: 2021.04.20-416508-416508; REH_PRODUCT_PICTURE: https://static.rehau.com/bim/images/1000/jpg/M-160346.jpg; Type Name: RPP; URL: www.rehau.com
Type - Materials and Finishes - REH_MATERIAL: RAUPIANO PLUS
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Description: REHAU_RAUPIANO PLUS Double socket
Pset_EnvironmentalImpactIndicators - Reference: RAUPIANO PLUS Double socket_For Gully:RPP; sets with these values: 2
Other - IsCustom: no; Type: RPP; Family: RAUPIANO PLUS Double socket_For Gully; Family and Type: RAUPIANO PLUS Double socket_For Gully: RPP; Type Id: 244480
Constraints - Level: Ground floor; Moves With Nearby Elements: no
Construction - REH_SLIP-ON SOCKET: no; Nominal Diameter: 50 mm
Dimensions - Area: 0.000517145 m2; DN1: 50 mm; DN2: 50 mm; Dr1: 64 mm; Dr2: 64 mm; j1: 3.4 mm; j2: 3.4 mm; L1: 44.5 mm; L2: 44.5 mm; P1: 43.5 mm; P2: 43.5 mm; t1: 11 mm; t2: 11 mm; Volume: 0.0000490005 m3; Z1: 1 mm; Z2: 1 mm
Graphics - Use Annotation Scale: no
Identity Data - REH_DESCRIPTION_SHORT: REHAU_RAUPIANO PLUS Double socket; REH_GTIN: 4062178590673; REH_MANUFACTURER_PID: 11326241001; REH_NETWEIGHT_G/PC: 74; REH_NOMINAL_DIAMETER: DN 50; REH_SUPPLIER_PID: 11326241001
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUPIANO PLUS Double socket_For Gully:RPP:...) | Elevation from Level (mm)
244769 | 4.90721
244770 | 4.92027
244771 | 4.92027

# IfcPipeFitting: RAUPIANO PLUS Offset branch max flow:RPP (8)
In: Ground floor
Type - Material: RAUPIANO PLUS
Type - Other - Category: Pipe Fittings; Family Name: RAUPIANO PLUS Offset branch max flow; T1: RP Offset branch; T2: RP Offset branch DN1-DN4; T3: RP Pipe size
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Manufacturer: REHAU; Model: RAUPIANO PLUS; REHAU Info: 2024.08.13-419114-419114; Type Name: RPP; URL: www.rehau.com
Type - Materials and Finishes - REH_MATERIAL: RAUPIANO PLUS
Type - Mechanical - Loss Method: K Coefficient from Table; K Coefficient Table: Converging/Diverging Tee/Wye
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUPIANO PLUS Offset branch max flow:RPP; sets with these values: 2
Other - IsCustom: no; Type: RPP; Family: RAUPIANO PLUS Offset branch max flow; Family and Type: RAUPIANO PLUS Offset branch max flow: RPP; Type Id: 57357
Constraints - Elevation from Level: 0 mm; Level: Ground floor
Construction - REH_PIPE_SOCKET: yes; REH_SLOPE: yes
Data - PID Check: 1 mm
Dimensions - Angle: 87 deg; REH_ANGLE_CHECK: 87 deg; Area: 0.000517145 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class code: EC003025
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUPIANO PLUS Offset branch max flow:RPP:...) | Description | REH_FLIP | Nominal Diameter 1 (mm) = Nominal Diameter 2 (mm) = DN1 (mm) = DN2 (mm) = Maximum Size (mm) | Nominal Diameter 3 (mm) = DN3 (mm) | Nominal Diameter 4 (mm) = DN4 (mm) = Minimum Size (mm) | REH_UNILATERAL_DOUBLE_BRANCH | Do2 (mm) | Dr1 (mm) | Dr3 (mm) | Dr4 (mm) | j1 (mm) | j3 (mm) | j4 (mm) | L1 (mm) | L2 (mm) | L3 (mm) | L4 (mm) | L5 (mm) | P1 (mm) | P3 (mm) | P4 (mm) | Q2 (mm) | r (mm) | Size = Overall Size | t1 (mm) | t3 (mm) | t4 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Z3 (mm) | Z4 (mm) | Z5 (mm) | Description long | GTIN | PID | Weight
137823 | RAUPIANO PLUS Unilat. double branch DN/OD 90/90/50, 87 degree, max flow | no | 90 | 90 | 50 | yes | 90.2 | 105 | 105 | 64 | 3 | 3 | 3.4 | 118 | 84 | 118 | 104 | 105 | 56 | 56 | 44 | 56 | 65.3344 | 90 mmø-90 mmø-90 mmø-50 mmø | 12.5 | 12.5 | 11 | 0.000309662 | 62 | 28 | 62 | 60 | 104 | RAUPIANO PLUS Unilat. double branch DN/OD 90/90/50, 87 degree, max flow | 4007360584412 | 11009281002 | 618.96
138089 | RAUPIANO PLUS Unilat. double branch DN/OD 110/110/50, 87 degree, max flow | no | 110 | 110 | 50 | yes | 110.2 | 127.4 | 127.4 | 64 | 3.6 | 3.6 | 3.4 | 103 | 80 | 122 | 94 | 106 | 52 | 52 | 44 | 52 | 73.7646 | 110 mmø-110 mmø-110 mmø-50 mmø | 13.9 | 13.9 | 11 | 0.000426051 | 51 | 28 | 70 | 50 | 116 | RAUPIANO PLUS Unilat. double branch DN/OD 110/110/50, 87 degree, max flow | 4007360584429 | 11009291002 | 1001
138237 | RAUPIANO PLUS Unilat. double branch DN/OD 90/90/50, 87 degree, max flow | no | 90 | 90 | 50 | no | 90.2 | 105 | 105 | 64 | 3 | 3 | 3.4 | 118 | 84 | 118 | 104 | 105 | 56 | 56 | 44 | 56 | 65.3344 | 90 mmø-90 mmø-90 mmø-50 mmø | 12.5 | 12.5 | 11 | 0.00030966 | 62 | 28 | 62 | 60 | 104 | RAUPIANO PLUS Offset branch left DN/OD 90/90/50, 87 degree | 4059757634422 | 11009581001 | 618.96
142548 | RAUPIANO PLUS Offset branch right DN/OD 110/90/75, 87 degree, max flow | no | 110 | 90 | 75 | no | 110.2 | 127.4 | 105 | 89 | 3.6 | 3 | 3.3 | 107 | 96 | 112 | 134 | 148 | 59 | 52 | 55 | 56 | 63.2268 | 110 mmø-110 mmø-90 mmø-75 mmø | 13.9 | 12.5 | 11.2 | 0.000467601 | 48 | 40 | 60 | 79 | 148 | RAUPIANO PLUS Offset branch left DN/OD 110/90/75, 87 degree, max flow | 4007360584382 | 11026891002 | 755.51
142684 | RAUPIANO PLUS Offset branch right DN/OD 110/110/75, 87 degree, max flow | no | 110 | 110 | 75 | no | 110.2 | 127.4 | 127.4 | 89 | 3.6 | 3.6 | 3.3 | 114 | 96 | 122 | 135 | 149 | 56 | 62 | 57 | 56 | 63.2268 | 110 mmø-110 mmø-110 mmø-75 mmø | 13.9 | 13.9 | 11.2 | 0.000523533 | 58 | 40 | 60 | 78 | 148 | RAUPIANO PLUS Offset branch left DN/OD 110/110/75, 87 degree, max flow | 4007360584405 | 11026781002 | 1050
142782 | RAUPIANO PLUS Unilat. double branch DN/OD 90/90/50, 87 degree, max flow | yes | 90 | 90 | 50 | no | 90.2 | 105 | 105 | 64 | 3 | 3 | 3.4 | 118 | 84 | 118 | 104 | 105 | 56 | 56 | 44 | 56 | 65.3344 | 90 mmø-90 mmø-90 mmø-50 mmø | 12.5 | 12.5 | 11 | 0.00030966 | 62 | 28 | 62 | 60 | 104 | RAUPIANO PLUS Offset branch right DN/OD 90/90/50, 87 degree | 4059757634415 | 11009361001 | 618.96
142791 | RAUPIANO PLUS Offset branch right DN/OD 110/90/75, 87 degree, max flow | yes | 110 | 90 | 75 | no | 110.2 | 127.4 | 105 | 89 | 3.6 | 3 | 3.3 | 107 | 96 | 112 | 134 | 148 | 59 | 52 | 55 | 56 | 63.2268 | 110 mmø-110 mmø-90 mmø-75 mmø | 13.9 | 12.5 | 11.2 | 0.000467601 | 48 | 40 | 60 | 79 | 148 | RAUPIANO PLUS Offset branch right DN/OD 110/90/75, 87 degree, max flow | 4007360584375 | 11026791002 | 755.51
142796 | RAUPIANO PLUS Offset branch right DN/OD 110/110/75, 87 degree, max flow | yes | 110 | 110 | 75 | no | 110.2 | 127.4 | 127.4 | 89 | 3.6 | 3.6 | 3.3 | 114 | 96 | 122 | 135 | 149 | 56 | 62 | 57 | 56 | 63.2268 | 110 mmø-110 mmø-110 mmø-75 mmø | 13.9 | 13.9 | 11.2 | 0.000523533 | 58 | 40 | 60 | 78 | 148 | RAUPIANO PLUS Offset branch right DN/OD 110/110/75, 87 degree, max flow | 4007360584399 | 11026771002 | 1050

# IfcPipeFitting: RAUPIANO PLUS Parallel branch:RPP (2)
In: Ground floor
Type - Material: RAUPIANO PLUS
Type - Other - Category: Pipe Fittings; Family Name: RAUPIANO PLUS Parallel branch; T1: RP Parallel branch; T2: RP Parallel branch DN1-DN3; T3: RP Pipe Size
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Manufacturer: REHAU; Model: RAUPIANO PLUS; REHAU Info: 2024.08.14-419114-419114; Type Name: RPP; URL: www.rehau.com
Type - Materials and Finishes - REH_MATERIAL: RAUPIANO PLUS
Type - Mechanical - Loss Method: K Coefficient from Table; K Coefficient Table: Converging/Diverging Tee/Wye
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Description: No description found
Pset_EnvironmentalImpactIndicators - Reference: RAUPIANO PLUS Parallel branch:RPP; sets with these values: 2
Other - IsCustom: no; Type: RPP; Family: RAUPIANO PLUS Parallel branch; Family and Type: RAUPIANO PLUS Parallel branch: RPP; Type Id: 60735
Constraints - Elevation from Level: 0 mm; Level: Ground floor
Construction - REH_PIPE_SOCKET: yes
Data - PID Check: 1 mm
Dimensions - Angle: 45 deg; Area: 0.000517145 m2; REH_ANGLE_CHECK: 45 deg
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class code: EC003025
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUPIANO PLUS Parallel branch:RPP:...) | Nominal Radius 1 (mm) = Nominal Radius 2 (mm) = Nominal Radius 3 (mm) | Nominal Diameter 1 (mm) = Nominal Diameter 2 (mm) = Nominal Diameter 3 (mm) = DN1 (mm) = DN2 (mm) = DN3 (mm) = Maximum Size (mm) = Minimum Size (mm) | Do1 (mm) | Dr2 (mm) = Dr3 (mm) | j2 (mm) = j3 (mm) | L1 (mm) | L2 (mm) = P2 (mm) | L3 (mm) | P3 (mm) | Q1 (mm) | Size = Overall Size | t2 (mm) = t3 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Z3 (mm) | Z4 (mm) | Description long | GTIN | PID | Weight
143000 | 45 | 90 | 90.2 | 105 | 3 | 78 | 69 | 162 | 52 | 57 | 90 mmø-90 mmø-90 mmø | 12.5 | 0.00030618 | 21 | 125 | 110 | 108 | RAUPIANO PLUS Parallel branch DN/OD 90/90 | 4007360584443 | 11237341002 | 614.61
150136 | 55 | 110 | 110.2 | 127.4 | 3.6 | 81 | 85 | 192 | 56 | 56 | 110 mmø-110 mmø-110 mmø | 13.9 | 0.000516532 | 25 | 151 | 136 | 122 | RAUPIANO PLUS Parallel branch DN/OD 110/110 | 4007360584450 | 11205641003 | 883.025

# IfcPipeFitting: RAUPIANO PLUS Pipe Socket_Nested:RPP, RAUPIANO PLUS Pipe Socket_Nested:RPP:244768
In: Ground floor
Type - Description: Pipe socket; Material: RAUPIANO PLUS
Type - Other - Category: Pipe Fittings; Family Name: RAUPIANO PLUS Pipe Socket_Nested
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; REH_INFO: 2021.02.09-416508-416508; Type Name: RPP; URL: www.rehau.com
Type - Materials and Finishes - REH_MATERIAL: RAUPIANO PLUS
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUPIANO PLUS Pipe Socket_Nested:RPP; sets with these values: 2
Other - IsCustom: no; Type: RPP; Family: RAUPIANO PLUS Pipe Socket_Nested; Family and Type: RAUPIANO PLUS Pipe Socket_Nested: RPP; Type Id: 244538
Constraints - Level: Ground floor; Moves With Nearby Elements: no; Elevation from Level: 3.24139 mm
Construction - REH_BEND_FLIP: yes
Dimensions - Area: 0.0137482 m2; Dmax: 79 mm; Dr: 89 mm; Nominal Diameter: 75 mm; Nominal Radius: 37.5 mm; Socket-j: 3.2 mm; Socket-P: 49.5 mm; Socket-t: 11.9 mm; Volume: 0.000039154 m3
Graphics - Use Annotation Scale: no
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm

# IfcPipeFitting: RAUPIANO PLUS Reducer:RPP (13)
In: Ground floor
Type - Material: RAUPIANO PLUS
Type - Other - Category: Pipe Fittings; Family Name: RAUPIANO PLUS Reducer; T1: RP Reducer; T2: RP Reducer DN1; T3: RP Pipe Size
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Classification Number: 23.60.30.11.14; ETIM Class code: EC003025; Manufacturer: REHAU; Model: RAUPIANO PLUS; REHAU Info: 2024.08.15-419114-419114; Type Name: RPP; URL: www.rehau.com
Type - Materials and Finishes - REH_MATERIAL: RAUPIANO PLUS
Type - Mechanical - K Coefficient Table: Converging/Diverging Tee/Wye; Loss Method: Not Defined
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUPIANO PLUS Reducer:RPP; sets with these values: 2
Other - IsCustom: no; Type: RPP; Family: RAUPIANO PLUS Reducer; Family and Type: RAUPIANO PLUS Reducer: RPP; Type Id: 31036
Constraints - Elevation from Level: 0 mm; Level: Ground floor
Construction - REH_PIPE_SOCKET: yes; Eccentric: yes; REH_BEND_FLIP (default): no
Data - PID Check: 1 mm
Dimensions - Area: 0.000516377 m2; OffsetHeight: 0; OffsetWidth: 0
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUPIANO PLUS Reducer:RPP:...) | Description = Description long | Nominal Diameter 1 (mm) = DN1 (mm) = Maximum Size (mm) | Nominal Diameter 2 (mm) = DN2 (mm) = Minimum Size (mm) | Do1 (mm) | Dr2 (mm) | E (mm) | j2 (mm) | L1 (mm) | L2 (mm) | P2 (mm) | Q1 (mm) | Size = Overall Size | t2 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | GTIN | PID | Weight
105744 | RAUPIANO PLUS Reducer DN/OD 40/32 | 40 | 32 | 40.1 | 43 | 4 | 3.4 | 50 | 49 | 39.8 | 44.2 | 40 mmø-32 mmø | 9.7 | 0.0000390739 | 5.8 | 9.2 | 4059757620036 | 11326101001 | 38
105875 | RAUPIANO PLUS Reducer DN/OD 50/32 | 50 | 32 | 50.1 | 43 | 9 | 3.4 | 52 | 49 | 39.3 | 45.7 | 50 mmø-32 mmø | 9.7 | 0.0000488984 | 6.3 | 9.7 | 4059757620043 | 11326131001 | 46
105918 | RAUPIANO PLUS Reducer DN/OD 50/40 | 50 | 40 | 50.1 | 54 | 5 | 3.4 | 50 | 50 | 42.3 | 45.7 | 50 mmø-40 mmø | 11 | 0.0000544087 | 4.3 | 7.7 | 4064299198905 | 11231241002 | 60.9
105978 | RAUPIANO PLUS Reducer DN/OD 75/50 | 75 | 50 | 75.2 | 64 | 12.5 | 3.4 | 59 | 56 | 44.3 | 50.7 | 75 mmø-50 mmø | 11 | 0.000116111 | 8.3 | 11.7 | 4007360525989 | 11213841002 | 101.15
106121 | RAUPIANO PLUS Reducer DN/OD 90/75 | 90 | 75 | 90.2 | 89 | 7.5 | 3.3 | 60 | 59 | 49.85 | 54.15 | 90 mmø-75 mmø | 11.2 | 0.000165679 | 5.85 | 9.15 | 4007360296728 | 11233241001 | 136
106178 | RAUPIANO PLUS Reducer DN/OD 90/50 | 90 | 50 | 90.2 | 64 | 20 | 3.4 | 67 | 59 | 42.8 | 54.2 | 90 mmø-50 mmø | 11 | 0.000181122 | 12.8 | 16.2 | 4007360296711 | 11233141001 | 130.8
106253 | RAUPIANO PLUS Reducer DN/OD 110/90 | 110 | 90 | 110.2 | 105 | 10 | 3 | 66 | 62 | 50.5 | 57.5 | 110 mmø-90 mmø | 12.5 | 0.000281866 | 8.5 | 11.5 | 4007360296247 | 11219941001 | 225
106299 | RAUPIANO PLUS Reducer DN/OD 110/75 | 110 | 75 | 110.2 | 89 | 17.5 | 3.3 | 74 | 65 | 50.35 | 62.65 | 110 mmø-75 mmø | 11.2 | 0.000289944 | 11.35 | 14.65 | 4064299198912 | 11214041002 | 206.23
106347 | RAUPIANO PLUS Reducer DN/OD 110/50 | 110 | 50 | 110.2 | 64 | 30 | 3.4 | 76 | 67 | 45.3 | 57.7 | 110 mmø-50 mmø | 11 | 0.000300481 | 18.3 | 21.7 | 4062178700645 | 11213941002 | 206.6
106463 | RAUPIANO PLUS Reducer DN/OD 125/110 | 125 | 110 | 125.2 | 127.4 | 7.5 | 3.6 | 68 | 64 | 54.7 | 62.3 | 125 mmø-110 mmø | 13.9 | 0.000352885 | 5.7 | 9.3 | 4007360078553 | 11206141001 | 317
106513 | RAUPIANO PLUS Reducer DN/OD 160/125 | 160 | 125 | 160.2 | 146 | 17.5 | 4.2 | 94 | 90 | 74.4 | 82.6 | 160 mmø-125 mmø | 16 | 0.000788925 | 11.4 | 15.6 | 4007360585198 | 11231051001 | 482
106555 | RAUPIANO PLUS Reducer DN/OD 160/110 | 160 | 110 | 160.2 | 127.4 | 25 | 3.6 | 85 | 73 | 52.2 | 67.8 | 160 mmø-110 mmø | 13.9 | 0.000802731 | 17.2 | 20.8 | 4007360434779 | 11240391001 | 513
106605 | RAUPIANO PLUS Reducer DN/OD 200/160 | 200 | 160 | 200.3 | 184 | 20 | 5.5 | 115 | 106 | 83.25 | 97.75 | 200 mmø-160 mmø | 18.4 | 0.00175005 | 17.25 | 22.75 | 4007360585181 | 11231021001 | 896

# IfcPipeFitting: RAUPIANO PLUS Shaft branch:RPP (4)
In: Ground floor
Type - Material: RAUPIANO PLUS
Type - Other - Category: Pipe Fittings; Family Name: RAUPIANO PLUS Shaft branch; T1: RP Shaft branch; T2: RP Shaft branch DN1-DN4; T3: RP Pipe size
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUPIANO PLUS; REHAU Info: 2024.08.13-419114-419114; Type Name: RPP; URL: www.rehau.com
Type - Materials and Finishes - REH_MATERIAL: RAUPIANO PLUS
Type - Mechanical - Loss Method: K Coefficient from Table; K Coefficient Table: Converging/Diverging Tee/Wye
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUPIANO PLUS Shaft branch:RPP; sets with these values: 2
Other - IsCustom: no; Type: RPP; Family: RAUPIANO PLUS Shaft branch; Family and Type: RAUPIANO PLUS Shaft branch: RPP; Type Id: 68470
Constraints - Elevation from Level: 0 mm; Level: Ground floor
Construction - REH_PIPE_SOCKET: yes; Nominal Diameter 4: 75 mm; REH_SLOPE: no
Data - PID Check: 1 mm
Dimensions - Angle: 90 deg; Area: 0.000517145 m2; DN4: 75 mm; Dr4: 89 mm; j4: 3.3 mm; Minimum Size: 75 mm; REH_ANGLE_CHECK: 87 deg; t4: 11.2 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class code: EC003025
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUPIANO PLUS Shaft branch:RPP:...) | Description | Flip | REH_FLIP | Nominal Diameter 1 (mm) = Nominal Diameter 2 (mm) = Nominal Diameter 3 (mm) = DN1 (mm) = DN2 (mm) = DN3 (mm) = Maximum Size (mm) | Do2 (mm) | Dr1 (mm) = Dr3 (mm) | j1 (mm) = j3 (mm) | L1 (mm) | L2 (mm) | L3 (mm) | L4 (mm) | P1 (mm) = P3 (mm) = Q2 (mm) | P4 (mm) | Size = Overall Size | t1 (mm) = t3 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | Z3 (mm) | Z4 (mm) | Z5 (mm) | Description long | GTIN | PID | Weight
129649 | RAUPIANO PLUS Shaft branch left DN/OD 90/75/90, 87 degree | 0 | no | 90 | 90.2 | 105 | 3 | 103 | 108 | 122 | 98 | 52 | 52 | 90 mmø-90 mmø-90 mmø-75 mmø | 12.5 | 0.000283039 | 51 | 56 | 70 | 46 | 59 | RAUPIANO PLUS Shaft branch right DN/OD 90/75/90, 87 degree | 4007360410407 | 11230451001 | 385
129769 | RAUPIANO PLUS Shaft branch left DN/OD 110/75/110, 87 degree | 0 | no | 110 | 110.2 | 127.4 | 3.6 | 118 | 113 | 118 | 97 | 56 | 34 | 110 mmø-110 mmø-110 mmø-75 mmø | 13.9 | 0.000389762 | 62 | 57 | 62 | 63 | 63 | RAUPIANO PLUS Shaft branch right DN/OD 110/75/110, 87 degree | 4007360406578 | 11237611001 | 610
129851 | RAUPIANO PLUS Shaft branch left DN/OD 90/75/90, 87 degree | 1 | yes | 90 | 90.2 | 105 | 3 | 103 | 108 | 122 | 98 | 52 | 52 | 90 mmø-90 mmø-90 mmø-75 mmø | 12.5 | 0.000283037 | 51 | 56 | 70 | 46 | 59 | RAUPIANO PLUS Shaft branch left DN/OD 90/75/90, 87 degree | 4007360410414 | 11230551001 | 385
129855 | RAUPIANO PLUS Shaft branch left DN/OD 110/75/110, 87 degree | 1 | yes | 110 | 110.2 | 127.4 | 3.6 | 118 | 113 | 118 | 97 | 56 | 34 | 110 mmø-110 mmø-110 mmø-75 mmø | 13.9 | 0.000389783 | 62 | 57 | 62 | 63 | 63 | RAUPIANO PLUS Shaft branch left DN/OD 110/75/110, 87 degree | 4007360406585 | 11237711001 | 625

# IfcPipeFitting: RAUPIANO PLUS Short Reducer:RPP (7)
In: Ground floor
Type - Material: RAUPIANO PLUS
Type - Other - Category: Pipe Fittings; Family Name: RAUPIANO PLUS Short Reducer; T1: RP Short Reducer; T2: RP Short Reducer DN1; T3: RP Pipe SIze
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Classification Number: 23.60.30.11.14; ETIM Class code: EC003025; Manufacturer: REHAU; Model: RAUPIANO PLUS; REHAU Info: 2024.08.15-419114-419114; Type Name: RPP; URL: www.rehau.com
Type - Materials and Finishes - REH_MATERIAL: RAUPIANO PLUS
Type - Mechanical - Loss Method: Not Defined; K Coefficient Table: Converging/Diverging Tee/Wye
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: RAUPIANO PLUS Short Reducer:RPP; sets with these values: 2
Other - IsCustom: no; Type: RPP; Family: RAUPIANO PLUS Short Reducer; Family and Type: RAUPIANO PLUS Short Reducer: RPP; Type Id: 72095
Constraints - Elevation from Level: 0 mm; Level: Ground floor
Construction - REH_PIPE_SOCKET: yes; Eccentric: yes; REH_FLIP (default): no
Data - PID Check: 1 mm
Dimensions - OffsetHeight: 0; OffsetWidth: 0; Area: 0.000516377 m2; Z1: 0 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUPIANO PLUS Short Reducer:RPP:...) | Description = Description long | Nominal Diameter 1 (mm) = DN1 (mm) = Maximum Size (mm) | Nominal Diameter 2 (mm) = DN2 (mm) = Minimum Size (mm) | Do1 (mm) | Do2 (mm) | Dr2 (mm) | E (mm) | j2 (mm) | P2 (mm) | Q1 (mm) | Size = Overall Size | t2 (mm) | Volume (m3) | Z2 (mm) | GTIN | PID | Weight
106896 | RAUPIANO PLUS Short reducer DN/OD 50/40 | 50 | 40 | 50.1 | 40.1 | 54 | 5 | 3.4 | 43 | 47 | 50 mmø-40 mmø | 11 | 0.0000275168 | 21 | 4059757376025 | 11200761001 | 38.5
107283 | RAUPIANO PLUS Short reducer DN/OD 75/50 | 75 | 50 | 75.2 | 50.1 | 64 | 12.5 | 3.4 | 45 | 51 | 75 mmø-50 mmø | 11 | 0.000044068 | 22 | 4059757376032 | 11200771001 | 62
107296 | RAUPIANO PLUS Short reducer DN/OD 90/75 | 90 | 75 | 90.2 | 75.2 | 89 | 7.5 | 3.3 | 50 | 54 | 90 mmø-75 mmø | 11.2 | 0.000065857 | 28 | 4059757376056 | 11200791001 | 128
107307 | RAUPIANO PLUS Short reducer DN/OD 110/90 | 110 | 90 | 110.2 | 90.2 | 105 | 10 | 3 | 52 | 58 | 110 mmø-90 mmø | 12.5 | 0.000101482 | 28 | 4059757376087 | 11200871001 | 223
107390 | RAUPIANO PLUS Short reducer DN/OD 90/50 | 90 | 50 | 90.2 | 50.1 | 64 | 20 | 3.4 | 43 | 54 | 90 mmø-50 mmø | 11 | 0.0000591289 | 25 | 4059757376049 | 11200781001 | 131
107510 | RAUPIANO PLUS Short reducer DN/OD 110/75 | 110 | 75 | 110.2 | 75.2 | 89 | 17.5 | 3.3 | 50 | 58 | 110 mmø-75 mmø | 11.2 | 0.0000952403 | 29 | 4059757376070 | 11200861001 | 217
107547 | RAUPIANO PLUS Short reducer DN/OD 110/50 | 110 | 50 | 110.2 | 50.1 | 64 | 30 | 3.4 | 45 | 58 | 110 mmø-50 mmø | 11 | 0.0000903243 | 22 | 4059757376063 | 11200851001 | 130

# IfcPipeFitting: RAUPIANO PLUS T-Piece:RPP (40)
In: Ground floor
Type - Material: RAUPIANO PLUS
Type - Other - Category: Pipe Fittings; Family Name: RAUPIANO PLUS T-Piece; T1: RPP; T2: DRPP T-Piece; T3: RPP T-Piece
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description en; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2030100; Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUPIANO PLUS; REHAU Info: 2024.10.29-420668-420668; Type Name: RPP; URL: https://bs.rehau.com/de-de/loesungen-fuer-die-gebaeudetechnik/sanitaer-und-trinkwasser/gebaeudeentwaesserung
Type - Materials and Finishes - RPP: RAUPIANO PLUS
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2030100 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: RAUPIANO PLUS T-Piece:RPP; sets with these values: 2
Other - IsCustom: no; Type: RPP; Family: RAUPIANO PLUS T-Piece; Family and Type: RAUPIANO PLUS T-Piece: RPP; Type Id: 16628
Constraints - Elevation from Level: 0 mm; Level: Ground floor
Data - PID Check: 1 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUPIANO PLUS T-Piece:RPP:...) | Angle check (deg) = Angle (deg) | L1 (mm) | L2 (mm) | L3 (mm) | s1 (mm) = s3 (mm) | s2 (mm) | Z1 (mm) | Z2 (mm) | Z3 (mm) | Area (m2) | Di1 (mm) = Di3 (mm) | Di2 (mm) | DN1 (mm) = DN3 (mm) = Maximum Size (mm) | DN2 (mm) = Minimum Size (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Weight
91279 | 87 | 69.1 | 59.3 | 60.2 | 1.6 | 1.6 | 25.9 | 16.1 | 17 | 0.0308247 | 28.8 | 28.8 | 32 | 32 | 32 mmø-32 mmø-32 mmø | 0.0000389959 | RAUPIANO PLUS Single branch DN/OD 32/32, 87 degree | 4059757976447 | 11326231001 | 68
91683 | 45 | 60 | 87.3 | 88.3 | 1.6 | 1.6 | 16.8 | 44.1 | 45.1 | 0.0347719 | 28.8 | 28.8 | 32 | 32 | 32 mmø-32 mmø-32 mmø | 0.0000451306 | RAUPIANO PLUS Single branch DN/OD 32/32, 45 degree | 4059757620029 | 11326071001 | 68
91739 | 87 | 65.3 | 67.3 | 67.3 | 1.8 | 1.8 | 19.5 | 21.5 | 21.5 | 0.0388878 | 36.4 | 36.4 | 40 | 40 | 40 mmø-40 mmø-40 mmø | 0.00005794 | RAUPIANO PLUS Single branch DN/OD 40/40, 87 degree | 4007360526016 | 11231141002 | 101.6
91741 | 45 | 52.3 | 91.3 | 91.3 | 1.8 | 1.8 | 6.5 | 45.5 | 45.5 | 0.0422066 | 36.4 | 36.4 | 40 | 40 | 40 mmø-40 mmø-40 mmø | 0.0000636008 | RAUPIANO PLUS Single branch DN/OD 40/40, 45 degree | 4059757660865 | 11231041002 | 113
91794 | 87 | 80 | 74.8 | 74.8 | 1.9 | 1.9 | 32.2 | 27 | 27 | 0.0512024 | 46.2 | 46.2 | 50 | 50 | 50 mmø-50 mmø-50 mmø | 0.0000836094 | RAUPIANO PLUS Single branch DN/OD 50/50, 87 degree | 4007360058500 | 11212541001 | 134.85
91796 | 45 | 64 | 105.8 | 105.8 | 1.9 | 1.9 | 16.2 | 58 | 58 | 0.0566777 | 46.2 | 46.2 | 50 | 50 | 50 mmø-50 mmø-50 mmø | 0.0000935883 | RAUPIANO PLUS Single branch DN/OD 50/50, 45 degree | 4007360058449 | 11212341001 | 150.5
91827 | 45 | 57.4 | 103.3 | 104.3 | 1.9 | 1.8 | 9.6 | 57.5 | 56.5 | 0.0521557 | 46.2 | 36.4 | 50 | 40 | 50 mmø-50 mmø-40 mmø | 0.0000847272 | RAUPIANO PLUS Single branch DN/OD 50/40, 45 degree | 4007360560379 | 11240891001 | 122
91897 | 87 | 91.6 | 94.6 | 94.6 | 1.9 | 1.9 | 36 | 39 | 39 | 0.0837889 | 71.2 | 71.2 | 75 | 75 | 75 mmø-75 mmø-75 mmø | 0.000143699 | RAUPIANO PLUS Single branch DN/OD 75/75, 87 degree | 4007360058524 | 11215441001 | 152
91899 | 45 | 69.6 | 142.6 | 142.6 | 1.9 | 1.9 | 14 | 87 | 87 | 0.0970304 | 71.2 | 71.2 | 75 | 75 | 75 mmø-75 mmø-75 mmø | 0.000168416 | RAUPIANO PLUS Single branch DN/OD 75/75, 45 degree | 4007360058463 | 11212941001 | 271
91901 | 45 | 50.6 | 123.3 | 125.6 | 1.9 | 1.9 | -5 | 75.5 | 70 | 0.0777826 | 71.2 | 46.2 | 75 | 50 | 75 mmø-75 mmø-50 mmø | 0.000133336 | RAUPIANO PLUS Single branch DN/OD 75/50, 45 degree | 4059757620623 | 11212641002 | 214
92084 | 87 | 73.4 | 72.3 | 73.3 | 1.9 | 1.8 | 25.6 | 26.5 | 25.5 | 0.047431 | 46.2 | 36.4 | 50 | 40 | 50 mmø-50 mmø-40 mmø | 0.0000762548 | RAUPIANO PLUS Single branch DN/OD 50/40, 87 degree | 4007360560386 | 11240971001 | 105
92086 | 87 | 78.6 | 87.3 | 82.6 | 1.9 | 1.9 | 23 | 39.5 | 27 | 0.0714266 | 71.2 | 46.2 | 75 | 50 | 75 mmø-75 mmø-50 mmø | 0.000121535 | RAUPIANO PLUS Single branch DN/OD 75/50, 87 degree | 4059757620616 | 11212841002 | 191
92204 | 87 | 126 | 115.3 | 103.3 | 2.2 | 2.2 | 69.5 | 58.8 | 46.8 | 0.116602 | 85.6 | 85.6 | 90 | 90 | 90 mmø-90 mmø-90 mmø | 0.000236648 | RAUPIANO PLUS Single branch DN/OD 90/90, 87 degree, max flow | 4007360296698 | 11233041001 | 368
92206 | 45 | 73 | 162 | 162 | 2.2 | 2.2 | 16.5 | 105.5 | 105.5 | 0.134863 | 85.6 | 85.6 | 90 | 90 | 90 mmø-90 mmø-90 mmø | 0.000277315 | RAUPIANO PLUS Single branch DN/OD 90/90, 45 degree | 4007360296681 | 11232941001 | 433
92208 | 45 | 44 | 134.3 | 135 | 2.2 | 1.9 | -12.5 | 86.5 | 78.5 | 0.0917926 | 85.6 | 46.2 | 90 | 50 | 90 mmø-90 mmø-50 mmø | 0.000180204 | RAUPIANO PLUS Single branch DN/OD 90/50, 45 degree | 4007360337315 | 11232741001 | 280
92210 | 87 | 80 | 94.3 | 84 | 2.2 | 1.9 | 23.5 | 46.5 | 27.5 | 0.0846429 | 85.6 | 46.2 | 90 | 50 | 90 mmø-90 mmø-50 mmø | 0.00016584 | RAUPIANO PLUS Single branch DN/OD 90/50, 87 degree | 4007360337322 | 11232841001 | 249
92247 | 87 | 99.1 | 102.6 | 96 | 2.2 | 1.9 | 42.6 | 47 | 39.5 | 0.099282 | 85.6 | 71.2 | 90 | 75 | 90 mmø-90 mmø-75 mmø | 0.000194418 | RAUPIANO PLUS Single branch DN/OD 90/75, 87 degree | 4007360388218 | 11238441001 | 295
92290 | 45 | 65 | 153.6 | 152 | 2.2 | 1.9 | 8.5 | 98 | 95.5 | 0.112293 | 85.6 | 71.2 | 90 | 75 | 90 mmø-90 mmø-75 mmø | 0.000219919 | RAUPIANO PLUS Single branch DN/OD 90/75, 45 degree | 4007360388201 | 11238341001 | 350
92621 | 87 | 131 | 134.6 | 114.6 | 2.7 | 2.7 | 69.9 | 73.5 | 53.5 | 0.156278 | 104.6 | 104.6 | 110 | 110 | 110 mmø-110 mmø-110 mmø | 0.000391517 | RAUPIANO PLUS Single branch DN/OD 110/110, 87 degree, max flow | 4007360394547 | 11230051001 | 613
92655 | 87 | 126 | 133.5 | 107.1 | 2.7 | 2.2 | 64.9 | 77 | 46 | 0.14276 | 104.6 | 85.6 | 110 | 90 | 110 mmø-110 mmø-90 mmø | 0.000343876 | RAUPIANO PLUS Single branch DN/OD 110/90, 87 degree, max flow | 4007360516130 | 11002581001 | 530
92741 | 87 | 96.1 | 111.6 | 101.1 | 2.7 | 1.9 | 35 | 56 | 40 | 0.120667 | 104.6 | 71.2 | 110 | 75 | 110 mmø-110 mmø-75 mmø | 0.000286587 | RAUPIANO PLUS Single branch DN/OD 110/75, 87 degree | 4007360058548 | 11213441001 | 432
92809 | 87 | 86 | 104.8 | 90 | 2.7 | 1.9 | 24.9 | 57 | 28.9 | 0.108021 | 104.6 | 46.2 | 110 | 50 | 110 mmø-110 mmø-50 mmø | 0.00025983 | RAUPIANO PLUS Single branch DN/OD 110/50, 87 degree | 4061264938696 | 11213241002 | 383
92949 | 45 | 81.1 | 190.1 | 190.1 | 2.7 | 2.7 | 20 | 129 | 129 | 0.173806 | 104.6 | 104.6 | 110 | 110 | 110 mmø-110 mmø-110 mmø | 0.000438798 | RAUPIANO PLUS Single branch DN/OD 110/110, 45 degree | 4007360397210 | 11229841001 | 714.5
92984 | 45 | 64 | 173 | 174.1 | 2.7 | 2.2 | 2.9 | 116.5 | 113 | 0.147831 | 104.6 | 85.6 | 110 | 90 | 110 mmø-110 mmø-90 mmø | 0.000354576 | RAUPIANO PLUS Single branch DN/OD 110/90, 45 degree | 4007360516147 | 11002571001 | 579
92993 | 45 | 57.1 | 167.6 | 165.1 | 2.7 | 1.9 | -4 | 112 | 104 | 0.136146 | 104.6 | 71.2 | 110 | 75 | 110 mmø-110 mmø-75 mmø | 0.000320929 | RAUPIANO PLUS Single branch DN/OD 110/75, 45 degree | 4007360058487 | 11213341001 | 491
93120 | 45 | 39.1 | 148.3 | 147.1 | 2.7 | 1.9 | -22 | 100.5 | 86 | 0.114388 | 104.6 | 46.2 | 110 | 50 | 110 mmø-110 mmø-50 mmø | 0.000273843 | RAUPIANO PLUS Single branch DN/OD 110/50, 45 degree | 4007360058470 | 11213041001 | 406
93402 | 87 | 134 | 132.4 | 132.4 | 3.1 | 3.1 | 66.6 | 65 | 65 | 0.184872 | 118.8 | 118.8 | 125 | 125 | 125 mmø-125 mmø-125 mmø | 0.000534435 | RAUPIANO PLUS Single branch DN/OD 125/125, 87 degree | 4007360078546 | 11206041001 | 816
93404 | 45 | 97 | 214.4 | 214.4 | 3.1 | 3.1 | 29.6 | 147 | 147 | 0.223035 | 118.8 | 118.8 | 125 | 125 | 125 mmø-125 mmø-125 mmø | 0.000651069 | RAUPIANO PLUS Single branch DN/OD 125/125, 45 degree | 4007360078539 | 11205841001 | 1051
93433 | 87 | 119.4 | 125.1 | 124.4 | 3.1 | 2.7 | 52 | 64 | 57 | 0.167639 | 118.8 | 104.6 | 125 | 110 | 125 mmø-125 mmø-110 mmø | 0.000470882 | RAUPIANO PLUS Single branch DN/OD 125/110, 87 degree | 4007360078522 | 11205941001 | 724
93435 | 45 | 85.4 | 181.1 | 219.4 | 3.1 | 2.7 | 18 | 120 | 152 | 0.200694 | 118.8 | 104.6 | 125 | 110 | 125 mmø-125 mmø-110 mmø | 0.000567668 | RAUPIANO PLUS Single branch DN/OD 125/110, 45 degree | 4007360078515 | 11205741001 | 881
93482 | 87 | 156 | 158.2 | 158.2 | 3.9 | 3.9 | 79.3 | 81.5 | 81.5 | 0.275605 | 152.2 | 152.2 | 160 | 160 | 160 mmø-160 mmø-160 mmø | 0.00100692 | RAUPIANO PLUS Single branch DN/OD 160/160, 87 degree | 4007360504878 | 11240771001 | 1476
93484 | 45 | 105.2 | 263.2 | 263.2 | 3.9 | 3.9 | 28.5 | 186.5 | 186.5 | 0.335487 | 152.2 | 152.2 | 160 | 160 | 160 mmø-160 mmø-160 mmø | 0.00123788 | RAUPIANO PLUS Single branch DN/OD 160/160, 45 degree | 4007360434762 | 11240381001 | 1974
93511 | 87 | 156 | 140.2 | 232.8 | 3.9 | 3.1 | 156.1 | 81 | 81.5 | 0.255593 | 152.2 | 118.8 | 160 | 125 | 160 mmø-160 mmø-125 mmø | 0.000910923 | RAUPIANO PLUS Single branch DN/OD 160/125, 87 degree | 4064299607087 | 11241281001 | 1400
93513 | 45 | 106.1 | 246 | 266.9 | 3.9 | 3.1 | 29.4 | 178.6 | 190.2 | 0.307778 | 152.2 | 118.8 | 160 | 125 | 160 mmø-160 mmø-125 mmø | 0.00108943 | RAUPIANO PLUS Single branch DN/OD 160/125, 45 degree | 4064299607070 | 11241271001 | 1856
94625 | 87 | 148.4 | 142.1 | 158.2 | 3.9 | 2.7 | 79.3 | 81 | 63.5 | 0.236322 | 152.2 | 104.6 | 160 | 110 | 160 mmø-160 mmø-110 mmø | 0.000833017 | RAUPIANO PLUS Single branch DN/OD 160/110, 87 degree | 4007360504861 | 11240691001 | 1218
96953 | 45 | 109 | 225.1 | 263.7 | 3.9 | 2.7 | 32.3 | 164 | 187 | 0.293178 | 152.2 | 104.6 | 160 | 110 | 160 mmø-160 mmø-110 mmø | 0.00103013 | RAUPIANO PLUS Single branch DN/OD 160/110, 45 degree | 4007360434755 | 11240371001 | 1507
97039 | 87 | 203 | 212.6 | 214.6 | 7.4 | 7.4 | 96.9 | 106.5 | 108.5 | 0.493602 | 185.2 | 185.2 | 200 | 200 | 200 mmø-200 mmø-200 mmø | 0.00341298 | RAUPIANO PLUS Single branch DN/OD 200/200, 87 degree | 4059757975600 | 11231221001 | 2717
97041 | 45 | 140 | 348 | 348 | 7.4 | 7.4 | 33.9 | 241.9 | 241.9 | 0.594135 | 185.2 | 185.2 | 200 | 200 | 200 mmø-200 mmø-200 mmø | 0.00413588 | RAUPIANO PLUS Single branch DN/OD 200/200, 45 degree | 4059757975624 | 11231181001 | 3672
97093 | 87 | 191 | 185.2 | 194.6 | 7.4 | 3.9 | 84.9 | 108.5 | 88.5 | 0.422062 | 185.2 | 152.2 | 200 | 160 | 200 mmø-200 mmø-160 mmø | 0.00271256 | RAUPIANO PLUS Single branch DN/OD 200/160, 87 degree | 4059757975617 | 11231191001 | 2231
97095 | 45 | 111.8 | 310.9 | 310.9 | 7.4 | 3.9 | 5.7 | 234.2 | 204.8 | 0.484509 | 185.2 | 152.2 | 200 | 160 | 200 mmø-200 mmø-160 mmø | 0.0029982 | RAUPIANO PLUS Single branch DN/OD 200/160, 45 degree | 4059757964932 | 11231171001 | 2771

# IfcPipeFitting: REHAU_RAUPIANO PLUS Pipe Socket_Nested:REHAU_RAUPIANO PLUS Pipe Socket_Nested (28)
In: Ground floor
Type - Description: Pipe socket; Material: RAUPIANO PLUS
Type - Other - Category: Pipe Fittings; Family Name: REHAU_RAUPIANO PLUS Pipe Socket_Nested
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; REH_INFO: 2021.02.09-416508-416508; Type Name: REHAU_RAUPIANO PLUS Pipe Socket_Nested; URL: www.rehau.com
Type - Materials and Finishes - REH_MATERIAL: RAUPIANO PLUS
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: REHAU_RAUPIANO PLUS Pipe Socket_Nested:REHAU_RAUPIANO PLUS Pipe Socket_Nested; sets with these values: 2
Other - IsCustom: no; Family: REHAU_RAUPIANO PLUS Pipe Socket_Nested; Family and Type: REHAU_RAUPIANO PLUS Pipe Socket_Nested: REHAU_RAUPIANO PLUS Pipe Socket_Nested; Type: REHAU_RAUPIANO PLUS Pipe Socket_Nested; Type Id: 105417
Constraints - Moves With Nearby Elements: no
Graphics - Use Annotation Scale: no
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (REHAU_RAUPIANO PLUS Pipe Socket_Nested:REHAU_RAUPIANO PLUS Pipe Socket_Nested:...) | Elevation from Level (mm) | Level | REH_BEND_FLIP | Area (m2) | Dmax (mm) | Dr (mm) | Nominal Diameter (mm) | Nominal Radius (mm) | Socket-j (mm) | Socket-P (mm) | Socket-t (mm) | Volume (m3)
102088 | 0 | Ground floor | no | 0.00858036 | 53.7 | 64 | 50 | 25 | 3.3 | 44.6 | 11.7 | 0.0000246684
102614 | 0 | Ground floor | no | 0.0137482 | 79 | 89 | 75 | 37.5 | 3.2 | 49.5 | 11.9 | 0.000039154
102625 | 0 | Ground floor | no | 0.0169979 | 94.6 | 105 | 90 | 45 | 2.9 | 51.3 | 13.6 | 0.0000553868
102636 | 0 | Ground floor | no | 0.0225682 | 115.4 | 127.4 | 110 | 55 | 3.5 | 55.1 | 14.6 | 0.0000864218
102781 | 0 | Ground floor | no | 0.0225682 | 115.4 | 127.4 | 110 | 55 | 3.5 | 55.1 | 14.6 | 0.0000864218
129555 | 238.919 |  | yes | 0.0225682 | 115.4 | 127.4 | 110 | 55 | 3.5 | 55.1 | 14.6 | 0.0000864218
129650 | -97.2 | Ground floor | yes | 0.0169979 | 94.6 | 105 | 90 | 45 | 2.9 | 51.3 | 13.6 | 0.0000553868
129770 | -97.2 | Ground floor | yes | 0.0225682 | 115.4 | 127.4 | 110 | 55 | 3.5 | 55.1 | 14.6 | 0.0000864218
129852 | -97.2 | Ground floor | yes | 0.0169979 | 94.6 | 105 | 90 | 45 | 2.9 | 51.3 | 13.6 | 0.0000553868
129856 | -97.2 | Ground floor | yes | 0.0225682 | 115.4 | 127.4 | 110 | 55 | 3.5 | 55.1 | 14.6 | 0.0000864218
137824 | -175.2 | Ground floor | yes | 0.0169979 | 94.6 | 105 | 90 | 45 | 2.9 | 51.3 | 13.6 | 0.0000553868
138090 | -175.2 | Ground floor | yes | 0.0225682 | 115.4 | 127.4 | 110 | 55 | 3.5 | 55.1 | 14.6 | 0.0000864218
138238 | -175.2 | Ground floor | yes | 0.0169979 | 94.6 | 105 | 90 | 45 | 2.9 | 51.3 | 13.6 | 0.0000553868
142549 | -175.2 | Ground floor | yes | 0.0225682 | 115.4 | 127.4 | 110 | 55 | 3.5 | 55.1 | 14.6 | 0.0000864218
142685 | -175.2 | Ground floor | yes | 0.0225682 | 115.4 | 127.4 | 110 | 55 | 3.5 | 55.1 | 14.6 | 0.0000864218
142783 | -175.2 | Ground floor | yes | 0.0169979 | 94.6 | 105 | 90 | 45 | 2.9 | 51.3 | 13.6 | 0.0000553868
142792 | -175.2 | Ground floor | yes | 0.0225682 | 115.4 | 127.4 | 110 | 55 | 3.5 | 55.1 | 14.6 | 0.0000864218
142797 | -175.2 | Ground floor | yes | 0.0225682 | 115.4 | 127.4 | 110 | 55 | 3.5 | 55.1 | 14.6 | 0.0000864218
143001 | 0 | Ground floor | yes | 0.0169979 | 94.6 | 105 | 90 | 45 | 2.9 | 51.3 | 13.6 | 0.0000553868
150137 | 0 | Ground floor | yes | 0.0225682 | 115.4 | 127.4 | 110 | 55 | 3.5 | 55.1 | 14.6 | 0.0000864218
150222 | 0 | Ground floor | yes | 0.0169979 | 94.6 | 105 | 90 | 45 | 2.9 | 51.3 | 13.6 | 0.0000553868
158510 | 0 | Ground floor | yes | 0.0225682 | 115.4 | 127.4 | 110 | 55 | 3.5 | 55.1 | 14.6 | 0.0000864218
162740 | 0 | Ground floor | yes | 0.0225682 | 115.4 | 127.4 | 110 | 55 | 3.5 | 55.1 | 14.6 | 0.0000864218
166984 | 0 | Ground floor | yes | 0.0225682 | 115.4 | 127.4 | 110 | 55 | 3.5 | 55.1 | 14.6 | 0.0000864218
167200 | 0 | Ground floor | yes | 0.0284438 | 131.2 | 146 | 125 | 62.5 | 4.1 | 60 | 16.7 | 0.000126586
167584 | 0 | Ground floor | yes | 0.0411255 | 167.7 | 184 | 160 | 80 | 5.4 | 67.6 | 19.4 | 0.000219982
218990 | 0 | Ground floor | yes | 0.00671638 | 43.6 | 54 | 40 | 20 | 3.3 | 42.6 | 11.7 | 0.000019834
221857 | 0 | Ground floor | yes | 0.00858036 | 53.7 | 64 | 50 | 25 | 3.3 | 44.6 | 11.7 | 0.0000246684

# IfcPipeFitting: REHAU_RAUPIANO PLUS Pipe Socket_Nested:RPP 2 (37)
In: Ground floor
Type - Description: Pipe socket; Material: RAUPIANO PLUS
Type - Other - Category: Pipe Fittings; Family Name: REHAU_RAUPIANO PLUS Pipe Socket_Nested
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; REH_INFO: 2021.02.09-416508-416508; Type Name: RPP 2; URL: www.rehau.com
Type - Materials and Finishes - REH_MATERIAL: RAUPIANO PLUS
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: REHAU_RAUPIANO PLUS Pipe Socket_Nested:RPP 2; sets with these values: 2
Other - IsCustom: no; Family: REHAU_RAUPIANO PLUS Pipe Socket_Nested; Family and Type: REHAU_RAUPIANO PLUS Pipe Socket_Nested: RPP 2; Type: RPP 2; Type Id: 20648
Constraints - Level: Ground floor; Moves With Nearby Elements: no
Graphics - Use Annotation Scale: no
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (REHAU_RAUPIANO PLUS Pipe Socket_Nested:RPP 2:...) | Elevation from Level (mm) | REH_BEND_FLIP | Area (m2) | Dmax (mm) | Dr (mm) | Nominal Diameter (mm) | Nominal Radius (mm) | Socket-j (mm) | Socket-P (mm) | Socket-t (mm) | Volume (m3)
105745 | 0 | yes | 0.00671638 | 43.6 | 54 | 40 | 20 | 3.3 | 42.6 | 11.7 | 0.000019834
105876 | 0 | yes | 0.00858036 | 53.7 | 64 | 50 | 25 | 3.3 | 44.6 | 11.7 | 0.0000246684
105919 | 0 | yes | 0.00858036 | 53.7 | 64 | 50 | 25 | 3.3 | 44.6 | 11.7 | 0.0000246684
105979 | 0 | yes | 0.0137482 | 79 | 89 | 75 | 37.5 | 3.2 | 49.5 | 11.9 | 0.000039154
106122 | 0 | yes | 0.0169979 | 94.6 | 105 | 90 | 45 | 2.9 | 51.3 | 13.6 | 0.0000553868
106179 | 0 | yes | 0.0169979 | 94.6 | 105 | 90 | 45 | 2.9 | 51.3 | 13.6 | 0.0000553868
106254 | 0 | yes | 0.0225682 | 115.4 | 127.4 | 110 | 55 | 3.5 | 55.1 | 14.6 | 0.0000864218
106300 | 0 | yes | 0.0225682 | 115.4 | 127.4 | 110 | 55 | 3.5 | 55.1 | 14.6 | 0.0000864218
106348 | 0 | yes | 0.0225682 | 115.4 | 127.4 | 110 | 55 | 3.5 | 55.1 | 14.6 | 0.0000864218
106464 | 0 | yes | 0.0284438 | 131.2 | 146 | 125 | 62.5 | 4.1 | 60 | 16.7 | 0.000126586
106514 | 0 | yes | 0.0411255 | 167.7 | 184 | 160 | 80 | 5.4 | 67.6 | 19.4 | 0.000219982
106556 | 0 | yes | 0.0411255 | 167.7 | 184 | 160 | 80 | 5.4 | 67.6 | 19.4 | 0.000219982
106606 | 0 | yes | 0.0328321 | 53.7 | 64 | 200 | 100 | 3.3 | 44.6 | 11.7 | 0.0000928206
106897 | 0 | no | 0.00858036 | 53.7 | 64 | 50 | 25 | 3.3 | 44.6 | 11.7 | 0.0000246684
107284 | 0 | no | 0.0137482 | 79 | 89 | 75 | 37.5 | 3.2 | 49.5 | 11.9 | 0.000039154
107297 | 0 | no | 0.0169979 | 94.6 | 105 | 90 | 45 | 2.9 | 51.3 | 13.6 | 0.0000553868
107308 | 0 | no | 0.0225682 | 115.4 | 127.4 | 110 | 55 | 3.5 | 55.1 | 14.6 | 0.0000864218
107391 | 0 | no | 0.0169979 | 94.6 | 105 | 90 | 45 | 2.9 | 51.3 | 13.6 | 0.0000553868
107511 | 0 | no | 0.0225682 | 115.4 | 127.4 | 110 | 55 | 3.5 | 55.1 | 14.6 | 0.0000864218
107548 | 0 | no | 0.0225682 | 115.4 | 127.4 | 110 | 55 | 3.5 | 55.1 | 14.6 | 0.0000864218
107613 | 0 | no | 0.00858036 | 53.7 | 64 | 50 | 25 | 3.3 | 44.6 | 11.7 | 0.0000246684
108064 | 0 | no | 0.0137482 | 79 | 89 | 75 | 37.5 | 3.2 | 49.5 | 11.9 | 0.000039154
108075 | 0 | no | 0.0169979 | 94.6 | 105 | 90 | 45 | 2.9 | 51.3 | 13.6 | 0.0000553868
108090 | 0 | no | 0.0225682 | 115.4 | 127.4 | 110 | 55 | 3.5 | 55.1 | 14.6 | 0.0000864218
108121 | 0 | no | 0.0284438 | 131.2 | 146 | 125 | 62.5 | 4.1 | 60 | 16.7 | 0.000126586
108132 | 0 | no | 0.0411255 | 167.7 | 184 | 160 | 80 | 5.4 | 67.6 | 19.4 | 0.000219982
108415 | 0 | yes | 0.00479758 | 35.7 | 43 | 32 | 16 | 3.4 | 38.9 | 9.7 | 0.0000120366
108683 | 0 | yes | 0.00671638 | 43.6 | 54 | 40 | 20 | 3.3 | 42.6 | 11.7 | 0.000019834
108694 | 0 | yes | 0.00858036 | 53.7 | 64 | 50 | 25 | 3.3 | 44.6 | 11.7 | 0.0000246684
108705 | 0 | yes | 0.0137482 | 79 | 89 | 75 | 37.5 | 3.2 | 49.5 | 11.9 | 0.000039154
108716 | 0 | yes | 0.0169979 | 94.6 | 105 | 90 | 45 | 2.9 | 51.3 | 13.6 | 0.0000553868
108727 | 0 | yes | 0.0225682 | 115.4 | 127.4 | 110 | 55 | 3.5 | 55.1 | 14.6 | 0.0000864218
108738 | 0 | yes | 0.0284438 | 131.2 | 146 | 125 | 62.5 | 4.1 | 60 | 16.7 | 0.000126586
108749 | 0 | yes | 0.0411255 | 167.7 | 184 | 160 | 80 | 5.4 | 67.6 | 19.4 | 0.000219982
108760 | 0 | yes | 0.0316004 | 43.6 | 54 | 200 | 100 | 3.3 | 42.6 | 11.7 | 0.0000908066
143020 | -104.2 | yes | 0.0225682 | 115.4 | 127.4 | 110 | 55 | 3.5 | 55.1 | 14.6 | 0.0000864218
143096 | -104.2 | yes | 0.0169979 | 94.6 | 105 | 90 | 45 | 2.9 | 51.3 | 13.6 | 0.0000553868

# IfcPipeSegment: Pipe Types:RAUPIANO PLUS (54)
In: Ground floor
Type - PredefinedType: RIGIDSEGMENT
Type - Other - Category: Pipes; Family Name: Pipe Types
Type - Identity Data - Manufacturer: REHAU; Model: RAUPIANO PLUS; Type Name: RAUPIANO PLUS
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_EnvironmentalImpactIndicators - Reference: Pipe Types:RAUPIANO PLUS; sets with these values: 2
Other - Family: Pipe Types; Family and Type: Pipe Types: RAUPIANO PLUS; Type: RAUPIANO PLUS; Type Id: 2307
Constraints - End Middle Elevation: 0 mm; Horizontal Justification: Center; Lower End Centerline Elevation: 0 mm; Middle Elevation: 0 mm; Reference Level: Ground floor; Slope: 0; Start Middle Elevation: 0 mm; Upper End Centerline Elevation: 0 mm; Vertical Justification: Middle
Mechanical - Connection Type: Generic; Material: RAUPIANO PLUS; Pipe Segment: RAUPIANO PLUS - 32-200; Roughness: 0.007 mm; Schedule/Type: 32-200; Segment Description: Sanitary; System Classification: Sanitary; System Type: Sanitary
Mechanical - Flow - Fixture Units: 0; Section: 1
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (Pipe Types:RAUPIANO PLUS:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Length (mm) | Outside Diameter (mm) = Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | System Name = Group | Relative Roughness
108956 | -14.2 | -16 | 14.2 | 16 | 28.4 | 150 | 32 | 32 mmø | 1.8 | 0.0150796 | Sanitary 1 | 0.000246479
109087 | -14.2 | -16 | 14.2 | 16 | 28.4 | 250 | 32 | 32 mmø | 1.8 | 0.0251327 | Sanitary 2 | 0.000246479
109198 | -14.2 | -16 | 14.2 | 16 | 28.4 | 500 | 32 | 32 mmø | 1.8 | 0.0502655 | Sanitary 3 | 0.000246479
109330 | -14.2 | -16 | 14.2 | 16 | 28.4 | 1000 | 32 | 32 mmø | 1.8 | 0.100531 | Sanitary 4 | 0.000246479
109444 | -14.2 | -16 | 14.2 | 16 | 28.4 | 2000 | 32 | 32 mmø | 1.8 | 0.201062 | Sanitary 5 | 0.000246479
109590 | -18.2 | -20 | 18.2 | 20 | 36.4 | 150 | 40 | 40 mmø | 1.8 | 0.0188496 | Sanitary 6 | 0.000192308
109593 | -18.2 | -20 | 18.2 | 20 | 36.4 | 250 | 40 | 40 mmø | 1.8 | 0.0314159 | Sanitary 7 | 0.000192308
109595 | -18.2 | -20 | 18.2 | 20 | 36.4 | 500 | 40 | 40 mmø | 1.8 | 0.0628319 | Sanitary 8 | 0.000192308
109597 | -18.2 | -20 | 18.2 | 20 | 36.4 | 1000 | 40 | 40 mmø | 1.8 | 0.125664 | Sanitary 9 | 0.000192308
109599 | -18.2 | -20 | 18.2 | 20 | 36.4 | 2000 | 40 | 40 mmø | 1.8 | 0.251327 | Sanitary 10 | 0.000192308
109634 | -18.2 | -20 | 18.2 | 20 | 36.4 | 3000 | 40 | 40 mmø | 1.8 | 0.376991 | Sanitary 11 | 0.000192308
109806 | -23.2 | -25 | 23.2 | 25 | 46.4 | 150 | 50 | 50 mmø | 1.8 | 0.0235619 | Sanitary 12 | 0.000150862
109809 | -23.2 | -25 | 23.2 | 25 | 46.4 | 250 | 50 | 50 mmø | 1.8 | 0.0392699 | Sanitary 13 | 0.000150862
109811 | -23.2 | -25 | 23.2 | 25 | 46.4 | 500 | 50 | 50 mmø | 1.8 | 0.0785398 | Sanitary 14 | 0.000150862
109813 | -23.2 | -25 | 23.2 | 25 | 46.4 | 1000 | 50 | 50 mmø | 1.8 | 0.15708 | Sanitary 15 | 0.000150862
109815 | -23.2 | -25 | 23.2 | 25 | 46.4 | 2000 | 50 | 50 mmø | 1.8 | 0.314159 | Sanitary 16 | 0.000150862
109817 | -23.2 | -25 | 23.2 | 25 | 46.4 | 3000 | 50 | 50 mmø | 1.8 | 0.471239 | Sanitary 17 | 0.000150862
109906 | -23.2 | -25 | 23.2 | 25 | 46.4 | 1500 | 50 | 50 mmø | 1.8 | 0.235619 | Sanitary 18 | 0.000150862
110130 | -35.6 | -37.5 | 35.6 | 37.5 | 71.2 | 150 | 75 | 75 mmø | 1.9 | 0.0353429 | Sanitary 19 | 0.0000983146
110133 | -35.6 | -37.5 | 35.6 | 37.5 | 71.2 | 250 | 75 | 75 mmø | 1.9 | 0.0589049 | Sanitary 20 | 0.0000983146
110135 | -35.6 | -37.5 | 35.6 | 37.5 | 71.2 | 500 | 75 | 75 mmø | 1.9 | 0.11781 | Sanitary 21 | 0.0000983146
110137 | -35.6 | -37.5 | 35.6 | 37.5 | 71.2 | 1000 | 75 | 75 mmø | 1.9 | 0.235619 | Sanitary 22 | 0.0000983146
110139 | -35.6 | -37.5 | 35.6 | 37.5 | 71.2 | 2000 | 75 | 75 mmø | 1.9 | 0.471239 | Sanitary 23 | 0.0000983146
110141 | -35.6 | -37.5 | 35.6 | 37.5 | 71.2 | 3000 | 75 | 75 mmø | 1.9 | 0.706858 | Sanitary 24 | 0.0000983146
110143 | -35.6 | -37.5 | 35.6 | 37.5 | 71.2 | 1500 | 75 | 75 mmø | 1.9 | 0.353429 | Sanitary 25 | 0.0000983146
110219 | -42.8 | -45 | 42.8 | 45 | 85.6 | 150 | 90 | 90 mmø | 2.2 | 0.0424115 | Sanitary 26 | 0.0000817757
110222 | -42.8 | -45 | 42.8 | 45 | 85.6 | 250 | 90 | 90 mmø | 2.2 | 0.0706858 | Sanitary 27 | 0.0000817757
110224 | -42.8 | -45 | 42.8 | 45 | 85.6 | 500 | 90 | 90 mmø | 2.2 | 0.141372 | Sanitary 28 | 0.0000817757
110226 | -42.8 | -45 | 42.8 | 45 | 85.6 | 1000 | 90 | 90 mmø | 2.2 | 0.282743 | Sanitary 29 | 0.0000817757
110228 | -42.8 | -45 | 42.8 | 45 | 85.6 | 2000 | 90 | 90 mmø | 2.2 | 0.565487 | Sanitary 30 | 0.0000817757
110230 | -42.8 | -45 | 42.8 | 45 | 85.6 | 3000 | 90 | 90 mmø | 2.2 | 0.84823 | Sanitary 31 | 0.0000817757
110232 | -42.8 | -45 | 42.8 | 45 | 85.6 | 1500 | 90 | 90 mmø | 2.2 | 0.424115 | Sanitary 32 | 0.0000817757
110306 | -42.8 | -45 | 42.8 | 45 | 85.6 | 2300 | 90 | 90 mmø | 2.2 | 0.65031 | Sanitary 33 | 0.0000817757

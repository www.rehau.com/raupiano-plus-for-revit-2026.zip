Properties of the parts of a building model (IFC4), part 3 of 3

# IfcPipeSegment: Pipe Types:RAUPIANO PLUS (54)
Name (Pipe Types:RAUPIANO PLUS:...) | InvertElevation (mm) = Lower End Invert Elevation (mm) = Upper End Invert Elevation (mm) = Invert Elevation (mm) | Lower End Bottom Elevation (mm) = Upper End Bottom Elevation (mm) = Lower End Bottom of Insulation Elevation (mm) = Upper End Bottom of Insulation Elevation (mm) | Lower End Obvert Elevation (mm) = Upper End Obvert Elevation (mm) | Lower End Top Elevation (mm) = Upper End Top Elevation (mm) = Lower End Top of Insulation Elevation (mm) = Upper End Top of Insulation Elevation (mm) | Inside Diameter (mm) | Length (mm) | Outside Diameter (mm) = Diameter (mm) | Size = Overall Size | Wall Thickness (mm) | Area (m2) | System Name = Group | Relative Roughness
110457 | -52.33 | -55 | 52.33 | 55 | 104.66 | 150 | 110 | 110 mmø | 2.67 | 0.0518363 | Sanitary 34 | 0.0000668832
110460 | -52.33 | -55 | 52.33 | 55 | 104.66 | 250 | 110 | 110 mmø | 2.67 | 0.0863938 | Sanitary 35 | 0.0000668832
110462 | -52.33 | -55 | 52.33 | 55 | 104.66 | 500 | 110 | 110 mmø | 2.67 | 0.172788 | Sanitary 36 | 0.0000668832
110464 | -52.33 | -55 | 52.33 | 55 | 104.66 | 1000 | 110 | 110 mmø | 2.67 | 0.345575 | Sanitary 37 | 0.0000668832
110466 | -52.33 | -55 | 52.33 | 55 | 104.66 | 2000 | 110 | 110 mmø | 2.67 | 0.69115 | Sanitary 38 | 0.0000668832
110468 | -52.33 | -55 | 52.33 | 55 | 104.66 | 3000 | 110 | 110 mmø | 2.67 | 1.03673 | Sanitary 39 | 0.0000668832
110470 | -52.33 | -55 | 52.33 | 55 | 104.66 | 1500 | 110 | 110 mmø | 2.67 | 0.518363 | Sanitary 40 | 0.0000668832
110599 | -59.4 | -62.5 | 59.4 | 62.5 | 118.8 | 150 | 125 | 125 mmø | 3.1 | 0.0589049 | Sanitary 41 | 0.0000589226
110602 | -59.4 | -62.5 | 59.4 | 62.5 | 118.8 | 250 | 125 | 125 mmø | 3.1 | 0.0981748 | Sanitary 42 | 0.0000589226
110604 | -59.4 | -62.5 | 59.4 | 62.5 | 118.8 | 500 | 125 | 125 mmø | 3.1 | 0.19635 | Sanitary 43 | 0.0000589226
110606 | -59.4 | -62.5 | 59.4 | 62.5 | 118.8 | 1000 | 125 | 125 mmø | 3.1 | 0.392699 | Sanitary 44 | 0.0000589226
110608 | -59.4 | -62.5 | 59.4 | 62.5 | 118.8 | 2000 | 125 | 125 mmø | 3.1 | 0.785398 | Sanitary 45 | 0.0000589226
110610 | -59.4 | -62.5 | 59.4 | 62.5 | 118.8 | 3000 | 125 | 125 mmø | 3.1 | 1.1781 | Sanitary 46 | 0.0000589226
110710 | -76 | -80 | 76 | 80 | 152 | 500 | 160 | 160 mmø | 4 | 0.251327 | Sanitary 47 | 0.0000460526
110712 | -76 | -80 | 76 | 80 | 152 | 1000 | 160 | 160 mmø | 4 | 0.502655 | Sanitary 48 | 0.0000460526
110714 | -76 | -80 | 76 | 80 | 152 | 2000 | 160 | 160 mmø | 4 | 1.00531 | Sanitary 49 | 0.0000460526
110716 | -76 | -80 | 76 | 80 | 152 | 3000 | 160 | 160 mmø | 4 | 1.50796 | Sanitary 50 | 0.0000460526
110821 | -52.33 | -55 | 52.33 | 55 | 104.66 | 5000 | 110 | 110 mmø | 2.67 | 1.72788 | Sanitary 51 | 0.0000668832
110905 | -93.7 | -100 | 93.7 | 100 | 187.4 | 1000 | 200 | 200 mmø | 6.3 | 0.628319 | Sanitary 52 | 0.0000373533
110907 | -93.7 | -100 | 93.7 | 100 | 187.4 | 2000 | 200 | 200 mmø | 6.3 | 1.25664 | Sanitary 53 | 0.0000373533
110909 | -93.7 | -100 | 93.7 | 100 | 187.4 | 3000 | 200 | 200 mmø | 6.3 | 1.88496 | Sanitary 54 | 0.0000373533

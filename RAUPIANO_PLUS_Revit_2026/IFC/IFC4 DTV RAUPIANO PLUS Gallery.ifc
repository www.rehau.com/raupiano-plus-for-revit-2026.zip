Properties of the parts of a building model (IFC4), part 1 of 3

# File
Description: ViewDefinition [DesignTransferView_V1.0], RevitIdentifiers [ContentGUID: 57c2985b-712e-4d4a-b910-d305c0ae9ef7, VersionGUID: 6e8cd26e-10e6-429f-ba29-0f5aecb88346, NumberOfSaves: 60], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site], ExchangeRequirement [BuildingService]
File name: IFC4 DTV RAUPIANO PLUS Gallery.ifc
Time: 2025-12-05T15:54:21+01:00
Written by: ODA SDAI 25.12
Made in: Autodesk - Revit 26.4.0.32 (ENG) - 26.4.0.32

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Ground floor
LongName: Ground floor; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level:Level 1
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1899
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Ground floor; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcBuildingElementProxy: Model Text:Model Text 1 (34)
In: Ground floor
Type - Other - Category: Generic Models; Family Name: Model Text
Type - Identity Data - Type Name: Model Text 1
Type - Text - Bold: no; Italic: no; Text Font: Arial; Text Size: 50 mm
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: Model Text:Model Text 1
Pset_EnvironmentalImpactIndicators - Reference: Model Text:Model Text 1
Other - Family: Model Text; Family and Type: Model Text: Model Text 1; Type: Model Text 1; Type Id: 1972
Constraints - Work Plane: Level : Ground floor
Dimensions - Depth: 25 mm
Identity Data - Subcategory: Generic Models
Materials and Finishes - Material: RAUPIANO PLUS
Phasing - Phase Created: New Construction
Name (Model Text:Model Text 1:...) | Horizontal Align | Text
222803 | Left | DN 32
222924 | Left | DN 40
222934 | Left | DN 50
222944 | Left | DN 75
222952 | Left | DN 90
222960 | Left | DN 110
222968 | Left | DN 125
222976 | Left | DN 160
222986 | Left | DN 200
234252 | Left | Elbow
234278 | Left | T-Piece
234295 | Left | Union
234316 | Left | Transition
234330 | Center | Union Inspection
234355 | Center | Cap
234368 | Center | Toilet Connection
234386 | Center | Elbow Deflection
234411 | Center | P-Siphon Ventilation
234450 | Center | T-Piece Parallel
234514 | Center | Junction
234539 | Center | Junction Shaft
234747 | Center | Junction Shaft Double Branch
234763 | Center | Junction Shaft Offset Branch
234851 | Center | Junction Shaft Corner Branch
234904 | Center | Floor waste gully (Only in Australia)
234951 | Left | DN 32
235024 | Left | DN 40
235049 | Left | DN 50
235079 | Left | DN 75
235087 | Left | DN 90
235095 | Left | DN 110
235103 | Left | DN 125
235113 | Left | DN 160
235121 | Left | DN 200

# IfcBuildingElementProxy: RAUPIANO PLUS Access pipe:RPP (6)
In: Ground floor
Type - Material: RAUPIANO PLUS
Type - Other - Category: Pipe Fittings; Family Name: RAUPIANO PLUS Access pipe; T1: RP Access pipe; T2: RP Access pipe DN1; T3: RP Pipe size
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Classification Number: 23.60.30.11.14; ETIM Class code: EC003024; Manufacturer: REHAU; REHAU Info: 2024.08.21-419114-419114; Type Name: RPP; URL: www.rehau.com
Type - Materials and Finishes - REH_MATERIAL: RAUPIANO PLUS
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: RAUPIANO PLUS Access pipe:RPP
Pset_EnvironmentalImpactIndicators - Reference: RAUPIANO PLUS Access pipe:RPP
Other - IsCustom: no; Type: RPP; Family: RAUPIANO PLUS Access pipe; Family and Type: RAUPIANO PLUS Access pipe: RPP; Type Id: 35831
Constraints - Elevation from Level: 0 mm; Level: Ground floor
Construction - REH_PIPE_SOCKET: yes
Dimensions - Area: 0.000517145 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUPIANO PLUS Access pipe:RPP:...) | Description = Description long | Nominal Diameter (mm) = DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | PID Check (mm) | DN3 (mm) | Do1 (mm) | Dr2 (mm) | j2 (mm) | L1 (mm) | L2 (mm) | L3 (mm) | P2 (mm) | Q1 (mm) | Size = Overall Size | t2 (mm) | Volume (m3) | Z1 (mm) | Z2 (mm) | GTIN | PID | Weight
107612 | RAUPIANO PLUS Access pipe DN/OD 50 | 50 | 1 | 70 | 50.1 | 64 | 3.4 | 92 | 87 | 55 | 43 | 47 | 50 mmø-50 mmø | 11 | 0.000150142 | 45 | 44 | 4007360560348 | 11210391001 | 231.5
108063 | RAUPIANO PLUS Access pipe DN/OD 75, with insert | 75 | 1 | 70 | 75.2 | 89 | 3.3 | 91 | 95 | 62 | 51 | 54 | 75 mmø-75 mmø | 11.2 | 0.000183724 | 37 | 44 | 4007360525637 | 11230791001 | 326.6
108074 | RAUPIANO PLUS Access pipe DN/OD 90 | 90 | 0 | 100 | 90.2 | 105 | 3 | 111 | 115 | 77 | 51 | 54 | 90 mmø-90 mmø | 12.5 | 0.000329013 | 57 | 64 | 4007360296827 | N/A | 580.5
108089 | RAUPIANO PLUS Access pipe DN/OD 110, with insert | 110 | 1 | 106 | 110.2 | 127.4 | 3.6 | 120 | 119 | 86 | 57 | 63 | 110 mmø-110 mmø | 13.9 | 0.000437044 | 57 | 62 | 4062178591472 | 11215341004 | 845.5
108120 | RAUPIANO PLUS Access pipe DN/OD 125 | 125 | 1 | 125 | 125.2 | 146 | 4.2 | 144 | 133 | 103 | 60 | 74 | 125 mmø-125 mmø | 16 | 0.000639834 | 70 | 73 | 4007360078591 | 11206341001 | 782
108131 | RAUPIANO PLUS Access pipe DN/OD 160, with insert | 160 | 1 | 106 | 160.2 | 184 | 5.5 | 156 | 159 | 112 | 69 | 70 | 160 mmø-160 mmø | 18.4 | 0.00085757 | 86 | 90 | 4059757620647 | 11240791001 | 1913

# IfcBuildingElementProxy: RAUPIANO PLUS Connection bend:RPP (2)
In: Ground floor
Type - Material: RAUPIANO PLUS
Type - Other - Category: Pipe Fittings; Family Name: RAUPIANO PLUS Connection bend; T1: RP Connection bend; T2: RP Connection bend DN1; T3: RP Pipe Size
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Classification Number: 23.60.30.11.14; ETIM Class code: EC010964; Manufacturer: REHAU; REHAU Info: 2024.08.22-419114-419114; Type Comments: RAUPIANO PLUS; Type Name: RPP; URL: www.rehau.com
Type - Materials and Finishes - REH_MATERIAL: RAUPIANO PLUS
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Description: No description found
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: RAUPIANO PLUS Connection bend:RPP
Pset_EnvironmentalImpactIndicators - Reference: RAUPIANO PLUS Connection bend:RPP
Other - IsCustom: no; Type: RPP; Family: RAUPIANO PLUS Connection bend; Family and Type: RAUPIANO PLUS Connection bend: RPP; Type Id: 218969
Constraints - Elevation from Level: 0 mm; Level: Ground floor
Construction - REH_PIPE_SOCKET: yes
Data - PID Check: 1 mm
Dimensions - Angle: 90 deg; Area: 0.000517145 m2; P2: 29 mm; REH_ANGLE_CHECK: 90 deg; Z1: 24 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0
Mechanical - System Classification: Sanitary
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUPIANO PLUS Connection bend:RPP:...) | Nominal Diameter (mm) = DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | Do1 (mm) = Do2 (mm) | Dr2 (mm) | L1 (mm) = s1 (mm) | L2 (mm) | Q1 (mm) | r (mm) = s2 (mm) = Z2 (mm) | Size = Overall Size | Volume (m3) | Description long | GTIN | PID | Weight
218989 | 40 | 40.1 | 54 | 88 | 49 | 64 | 20 | 40 mmø-40 mmø | 0.0000305546 | RAUPIANO PLUS Connection bend DN/OD 40/40-30 | 4007360296759 | 11231741001 | 35
221856 | 50 | 50.1 | 64 | 96 | 55 | 72 | 26 | 50 mmø-50 mmø | 0.0000409851 | RAUPIANO PLUS Connection bend DN/OD 50/40-30 | 4007360332860 | 11226941001 | 52

# IfcBuildingElementProxy: RAUPIANO PLUS Double socket:RPP (18)
In: Ground floor
Type - Material: RAUPIANO PLUS
Type - Other - Category: Pipe Fittings; Family Name: RAUPIANO PLUS Double socket; T1: RP Double socket; T2: RP Double socket DN1; T3: RP Pipe Size
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Classification Number: 23.60.30.11.14; ETIM Class code: EC003024; Manufacturer: REHAU; Model: RAUPIANO PLUS; REHAU Info: 2024.08.19-419114-419114; Type Name: RPP; URL: www.rehau.com
Type - Materials and Finishes - REH_MATERIAL: RAUPIANO PLUS
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_BuildingElementProxyCommon - Reference: RAUPIANO PLUS Double socket:RPP; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: RAUPIANO PLUS Double socket:RPP
Other - IsCustom: no; Type: RPP; Family: RAUPIANO PLUS Double socket; Family and Type: RAUPIANO PLUS Double socket: RPP; Type Id: 32872
Constraints - Elevation from Level: 0 mm; Level: Ground floor
Data - PID Check: 1 mm
Dimensions - Area: 0.000517145 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUPIANO PLUS Double socket:RPP:...) | Description | Nominal Diameter (mm) = DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | REH_SLIP-ON SOCKET | Dr1 (mm) = Dr2 (mm) | j1 (mm) = j2 (mm) | L1 (mm) = L2 (mm) | P1 (mm) = P2 (mm) | Size = Overall Size | t1 (mm) = t2 (mm) | Volume (m3) | Z1 (mm) = Z2 (mm) | Description long | GTIN | PID | Weight
97527 | RAUPIANO PLUS Double socket DN/OD 32 | 32 | no | 43 | 3.4 | 40.5 | 39.5 | 32 mmø-32 mmø | 9.7 | 0.0000254039 | 1 | RAUPIANO PLUS Double socket DN/OD 32 | 4059757620050 | 11326151001 | 31
98023 | RAUPIANO PLUS Double socket DN/OD 32 | 32 | yes | 43 | 3.4 | 40.5 | 39.5 | 32 mmø-32 mmø | 9.7 | 0.0000249759 | 1 | RAUPIANO PLUS Slip-on socket DN/OD 32 | 4059757620067 | 11326161001 | 31
101830 | RAUPIANO PLUS Double socket DN/OD 40 | 40 | no | 54 | 3.4 | 44.5 | 43.5 | 40 mmø-40 mmø | 11 | 0.0000404402 | 1 | RAUPIANO PLUS Double socket DN/OD 40 | 4007360296780 | 11231441001 | 37.3
101832 | RAUPIANO PLUS Double socket DN/OD 40 | 40 | yes | 54 | 3.4 | 44.5 | 43.5 | 40 mmø-40 mmø | 11 | 0.0000398969 | 1 | RAUPIANO PLUS Slip-on socket DN/OD 40 | 4007360296803 | 11231541001 | 37.1
101841 | RAUPIANO PLUS Double socket DN/OD 50 | 50 | no | 64 | 3.4 | 44.5 | 43.5 | 50 mmø-50 mmø | 11 | 0.0000490005 | 1 | RAUPIANO PLUS Double socket DN/OD 50 | 4062178590666 | 11326241001 | 74
101843 | RAUPIANO PLUS Double socket DN/OD 50 | 50 | yes | 64 | 3.4 | 44.5 | 43.5 | 50 mmø-50 mmø | 11 | 0.0000483117 | 1 | RAUPIANO PLUS Slip-on socket DN/OD 50 | 4062178590673 | 11326251001 | 73
101854 | RAUPIANO PLUS Double socket DN/OD 75 | 75 | no | 89 | 3.3 | 55.5 | 54.5 | 75 mmø-75 mmø | 11.2 | 0.0000840007 | 1 | RAUPIANO PLUS Double socket DN/OD 75 | 4062178591465 | 11215841002 | 129.1
101856 | RAUPIANO PLUS Double socket DN/OD 75 | 75 | yes | 89 | 3.3 | 55.5 | 54.5 | 75 mmø-75 mmø | 11.2 | 0.0000829501 | 1 | RAUPIANO PLUS Slip-on socket DN/OD 75 | 4062178591458 | 11215741002 | 127.75
101865 | RAUPIANO PLUS Double socket DN/OD 90 | 90 | no | 105 | 3 | 53.5 | 52.5 | 90 mmø-90 mmø | 12.5 | 0.000113288 | 1 | RAUPIANO PLUS Double socket DN/OD 90 | 4007360296797 | 11233441001 | 170
101867 | RAUPIANO PLUS Double socket DN/OD 90 | 90 | yes | 105 | 3 | 53.5 | 52.5 | 90 mmø-90 mmø | 12.5 | 0.000112021 | 1 | RAUPIANO PLUS Slip-on socket DN/OD 90 | 4007360296810 | 11233541001 | 167.8
101876 | RAUPIANO PLUS Double socket DN/OD 110 | 110 | no | 127.4 | 3.6 | 64 | 63 | 110 mmø-110 mmø | 13.9 | 0.000191852 | 1 | RAUPIANO PLUS Double socket DN/OD 110 | 4007360058692 | 11214941001 | 280
101878 | RAUPIANO PLUS Double socket DN/OD 110 | 110 | yes | 127.4 | 3.6 | 64 | 63 | 110 mmø-110 mmø | 13.9 | 0.000190295 | 1 | RAUPIANO PLUS Slip-on socket DN/OD 110 | 4007360058722 | 11215141001 | 279
101887 | RAUPIANO PLUS Double socket DN/OD 125 | 125 | no | 146 | 4.2 | 71 | 70 | 125 mmø-125 mmø | 16 | 0.000281742 | 1 | RAUPIANO PLUS Double socket DN/OD 125 | 4007360078577 | 11204741001 | 410
101889 | RAUPIANO PLUS Double socket DN/OD 125 | 125 | yes | 146 | 4.2 | 71 | 70 | 125 mmø-125 mmø | 16 | 0.000279968 | 1 | RAUPIANO PLUS Slip-on socket DN/OD 125 | 4007360078584 | 11204641001 | 406
101900 | RAUPIANO PLUS Double socket DN/OD 160 | 160 | no | 184 | 5.5 | 74 | 73 | 160 mmø-160 mmø | 18.4 | 0.000465044 | 1 | RAUPIANO PLUS Double socket DN/OD 160 | 4007360434786 | 11240471001 | 615
101902 | RAUPIANO PLUS Double socket DN/OD 160 | 160 | yes | 184 | 5.5 | 74 | 73 | 160 mmø-160 mmø | 18.4 | 0.000462764 | 1 | RAUPIANO PLUS Slip-on socket DN/OD 160 | 4007360434793 | 11240481001 | 607
101911 | RAUPIANO PLUS Double socket DN/OD 200 | 200 | no | 240 | 6.4 | 103 | 100 | 200 mmø-200 mmø | 24.2 | 0.00131163 | 3 | RAUPIANO PLUS Double socket DN/OD 200 | 4007360585167 | 11230981001 | 982
101913 | RAUPIANO PLUS Double socket DN/OD 200 | 200 | yes | 240 | 6.4 | 103 | 100 | 200 mmø-200 mmø | 24.2 | 0.00130305 | 3 | RAUPIANO PLUS Slip-on socket DN/OD 200 | 4007360585174 | 11230991001 | 947

# IfcBuildingElementProxy: RAUPIANO PLUS Long socket:RPP (5)
In: Ground floor
Type - Material: RAUPIANO PLUS
Type - Other - Category: Pipe Fittings; Family Name: RAUPIANO PLUS Long socket; T1: RP Long socket; T2: RP Long socket DN1; T3: RP Pipe Size
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Classification Number: 23.60.30.11.14; ETIM Class code: EC003024; Manufacturer: REHAU; REHAU Info: 2024.08.21-419114-419114; Type Name: RPP; URL: www.rehau.com
Type - Materials and Finishes - REH_MATERIAL: RAUPIANO PLUS
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: RAUPIANO PLUS Long socket:RPP
Pset_EnvironmentalImpactIndicators - Reference: RAUPIANO PLUS Long socket:RPP
Other - IsCustom: no; Type: RPP; Family: RAUPIANO PLUS Long socket; Family and Type: RAUPIANO PLUS Long socket: RPP; Type Id: 27649
Constraints - Elevation from Level: 0 mm; Level: Ground floor
Construction - REH_FLIP: no; REH_PIPE_SOCKET: yes
Data - PID Check: 1 mm
Dimensions - Area: 0.000517145 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUPIANO PLUS Long socket:RPP:...) | Description | Nominal Diameter (mm) = DN1 (mm) = DN2 (mm) = Maximum Size (mm) = Minimum Size (mm) | REH_LONG_SOCKET_XL | Do1 (mm) | Dr2 (mm) | j2 (mm) | L1 (mm) | L2 (mm) | P2 (mm) | Q1 (mm) | Size = Overall Size | t2 (mm) | Volume (m3) | Z1 (mm) = Z2 (mm) | Description long | GTIN | PID | Weight
102087 | RAUPIANO PLUS Long socket DN/OD 50 | 50 | no | 50.1 | 64 | 3.4 | 56 | 119 | 115 | 52 | 50 mmø-50 mmø | 11 | 0.0000629183 | 4 | RAUPIANO PLUS Long socket DN/OD 50 | 4062178676292 | 11241091001 | 97
102613 | RAUPIANO PLUS Long socket DN/OD 75 | 75 | no | 75.2 | 89 | 3.3 | 60 | 133 | 129 | 56 | 75 mmø-75 mmø | 11.2 | 0.000105673 | 4 | RAUPIANO PLUS Long socket DN/OD 75 | 4062178676308 | 11241171001 | 162
102624 | RAUPIANO PLUS Long socket DN/OD 90 | 90 | no | 90.2 | 105 | 3 | 54 | 120 | 115 | 49 | 90 mmø-90 mmø | 12.5 | 0.00013265 | 5 | RAUPIANO PLUS Long socket DN/OD 90 | 4007360296834 | 11233741001 | 225
102635 | RAUPIANO PLUS Long socket DN/OD 110 | 110 | no | 110.2 | 127.4 | 3.6 | 63 | 130 | 127 | 60 | 110 mmø-110 mmø | 13.9 | 0.000216997 | 3 | RAUPIANO PLUS Long socket DN/OD 110 | 4007360058753 | 11215941001 | 371
102780 | RAUPIANO PLUS Long socket DN/OD 110 | 110 | yes | 110.2 | 127.4 | 3.6 | 68 | 165 | 160 | 63 | 110 mmø-110 mmø | 13.9 | 0.000255897 | 5 | RAUPIANO PLUS Long socket DN/OD 110 XL | 4062178676315 | 11241181001 | 395

# IfcBuildingElementProxy: RAUPIANO PLUS P-Trap siphon:RPP, RAUPIANO PLUS P-Trap siphon:RPP:129554
In: Ground floor
Type - Description: RAUPIANO PLUS P-trap siphon DN/OD 110, 135 Degree; Material: <Unnamed>, RAUPIANO PLUS
Type - Other - Category: Pipe Fittings; Family Name: RAUPIANO PLUS P-Trap siphon; T1: RP P-trap siphon; T2: RP Pipe Size
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Manufacturer: REHAU; Model: RAUPIANO PLUS; REHAU Info: 2024.08.12-419114-419114; Type Name: RPP; URL: www.rehau.com
Type - Materials and Finishes - REH_MATERIAL: RAUPIANO PLUS
Type - Mechanical - K Coefficient Table: Converging/Diverging Tee/Wye; Loss Method: K Coefficient from Table
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Material: RAUPIANO PLUS
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: RAUPIANO PLUS P-Trap siphon:RPP
Pset_EnvironmentalImpactIndicators - Reference: RAUPIANO PLUS P-Trap siphon:RPP
Other - Type: RPP; Family: RAUPIANO PLUS P-Trap siphon; Family and Type: RAUPIANO PLUS P-Trap siphon: RPP; Type Id: 63988
Constraints - Elevation from Level: 0 mm; Work Plane: <not associated>
Construction - REH_PIPE_SOCKET: yes; Nominal Diameter: 110 mm
Data - PID Check: 1 mm
Dimensions - a: 135 deg; Area: 0.00306386 m2; DN1: 110 mm; DN2: 110 mm; Do1: 110.2 mm; Do2: 110.2 mm; j1: 3.6 mm; L1: 221 mm; L2: 298 mm; Maximum Size: 110 mm; Minimum Size: 110 mm; P1: 57 mm; Q2: 189 mm; Size: 110 mmø-110 mmø; t1: 13.9 mm; Volume: 0.00165842 m3; Z1: 164 mm; Z2: 109 mm
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; Description long: RAUPIANO PLUS P-trap siphon DN/OD 110, 135 Degree; ETIM Class code: EC003024; GTIN: 4007360440671; PID: 11230391001; Weight: 707
Mechanical - Pressure Drop: 0 Pa; System Classification: Undefined
Mechanical - Flow - Pressure Drop: 0 Pa
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm; Overall Size: 110 mmø-110 mmø

# IfcBuildingElementProxy: RAUPIANO PLUS Socket plug:RPP (9)
In: Ground floor
Type - Material: RAUPIANO PLUS
Type - Other - Category: Pipe Fittings; Family Name: RAUPIANO PLUS Socket plug; T1: RP Socket Plug; T2: RP Socket Plug DN1; T3: RP Pipe Size
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Classification Number: 23.60.30.11.14; Manufacturer: REHAU; Model: RAUPIANO PLUS; Type Name: RPP; URL: www.rehau.com
Type - Materials and Finishes - REH_MATERIAL: RAUPIANO PLUS
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: RAUPIANO PLUS Socket plug:RPP
Pset_EnvironmentalImpactIndicators - Reference: RAUPIANO PLUS Socket plug:RPP
Other - IsCustom: no; Type: RPP; Family: RAUPIANO PLUS Socket plug; Family and Type: RAUPIANO PLUS Socket plug: RPP; Type Id: 38188
Constraints - Elevation from Level: 0 mm; Level: Ground floor
Construction - REH_PIPE_SOCKET: yes
Data - PID Check: 1 mm
Dimensions - Area: 0.000517145 m2
Graphics - Use Annotation Scale: no
Identity Data - Sorting: 0; ETIM Class code: EC003025
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUPIANO PLUS Socket plug:RPP:...) | Description = Description long | Nominal Diameter (mm) = DN1 (mm) = Maximum Size (mm) = Minimum Size (mm) | Do1 (mm) | Dr1 (mm) | h1 (mm) | ID (mm) | L1 (mm) | Q1 (mm) | Size = Overall Size | Volume (m3) | GTIN | PID | Weight
108414 | RAUPIANO PLUS Socket plug DN/OD 32 | 32 | 32.1 | 47 | 2 | 28.4 | 35 | 32 | 32 mmø | 0.00000934326 | 4059757620074 | 11326141001 | 14
108682 | RAUPIANO PLUS Socket plug DN/OD 40 | 40 | 40.1 | 54 | 2 | 36.4 | 33 | 29 | 40 mmø | 0.0000114517 | 4062178676735 | 11231341003 | 22.2
108693 | RAUPIANO PLUS Socket plug DN/OD 50 | 50 | 50.1 | 64 | 2 | 46.4 | 34 | 30 | 50 mmø | 0.0000153933 | 4062178676759 | 11214541003 | 29.25
108704 | RAUPIANO PLUS Socket plug DN/OD 75 | 75 | 75.2 | 89 | 2 | 71.2 | 35 | 31 | 75 mmø | 0.0000276055 | 4062178676766 | 11214641003 | 52.5
108715 | RAUPIANO PLUS Socket plug DN/OD 90 | 90 | 90.2 | 104 | 2 | 85.6 | 37 | 32 | 90 mmø | 0.0000388793 | 4062178676773 | 11233341003 | 76.1
108726 | RAUPIANO PLUS Socket plug DN/OD 110 | 110 | 110.2 | 126 | 3 | 104.6 | 37 | 32 | 110 mmø | 0.0000699725 | 4062178676780 | 11214741003 | 134
108737 | RAUPIANO PLUS Socket plug DN/OD 125 | 125 | 125.2 | 148 | 3 | 118.8 | 40 | 35 | 125 mmø | 0.0000975658 | 4007360078560 | 11206241001 | 101.9
108748 | RAUPIANO PLUS Socket plug DN/OD 160 | 160 | 160.2 | 183 | 4 | 152.2 | 49 | 43 | 160 mmø | 0.000195435 | 4007360585204 | 11231061001 | 282
108759 | RAUPIANO PLUS Socket plug DN/OD 200 | 200 | 200.3 | 230 | 6 | 187.6 | 59 | 53 | 200 mmø | 0.000465808 | 4007360585211 | 11231091001 | 530

# IfcDistributionPort (572)
Description: Flow; PredefinedType: PIPE
Name | FlowDirection
Port_89192_1 | SOURCEANDSINK
Port_89192_2 | SOURCEANDSINK
Port_89504_1 | SOURCEANDSINK
Port_89504_2 | SOURCEANDSINK
Port_89579_1 | SOURCEANDSINK
Port_89579_2 | SOURCEANDSINK
Port_89651_1 | SOURCEANDSINK
Port_89651_2 | SOURCEANDSINK
Port_89713_1 | SOURCEANDSINK
Port_89713_2 | SOURCEANDSINK
Port_89715_1 | SOURCEANDSINK
Port_89715_2 | SOURCEANDSINK
Port_89717_1 | SOURCEANDSINK
Port_89717_2 | SOURCEANDSINK
Port_89719_1 | SOURCEANDSINK
Port_89719_2 | SOURCEANDSINK
Port_89750_1 | SOURCEANDSINK
Port_89750_2 | SOURCEANDSINK
Port_89836_1 | SOURCEANDSINK
Port_89836_2 | SOURCEANDSINK
Port_89838_1 | SOURCEANDSINK
Port_89838_2 | SOURCEANDSINK
Port_89840_1 | SOURCEANDSINK
Port_89840_2 | SOURCEANDSINK
Port_89842_1 | SOURCEANDSINK
Port_89842_2 | SOURCEANDSINK
Port_89844_1 | SOURCEANDSINK
Port_89844_2 | SOURCEANDSINK
Port_89892_1 | SOURCEANDSINK
Port_89892_2 | SOURCEANDSINK
Port_89894_1 | SOURCEANDSINK
Port_89894_2 | SOURCEANDSINK
Port_89896_1 | SOURCEANDSINK
Port_89896_2 | SOURCEANDSINK
Port_89898_1 | SOURCEANDSINK
Port_89898_2 | SOURCEANDSINK
Port_89900_1 | SOURCEANDSINK
Port_89900_2 | SOURCEANDSINK
Port_89948_1 | SOURCEANDSINK
Port_89948_2 | SOURCEANDSINK
Port_89950_1 | SOURCEANDSINK
Port_89950_2 | SOURCEANDSINK
Port_89952_1 | SOURCEANDSINK
Port_89952_2 | SOURCEANDSINK
Port_89954_1 | SOURCEANDSINK
Port_89954_2 | SOURCEANDSINK
Port_89956_1 | SOURCEANDSINK
Port_89956_2 | SOURCEANDSINK
Port_89975_1 | SOURCEANDSINK
Port_89975_2 | SOURCEANDSINK
Port_89977_1 | SOURCEANDSINK
Port_89977_2 | SOURCEANDSINK
Port_89979_1 | SOURCEANDSINK
Port_89979_2 | SOURCEANDSINK
Port_89981_1 | SOURCEANDSINK
Port_89981_2 | SOURCEANDSINK
Port_89983_1 | SOURCEANDSINK
Port_89983_2 | SOURCEANDSINK
Port_90017_1 | SOURCEANDSINK
Port_90017_2 | SOURCEANDSINK
Port_90019_1 | SOURCEANDSINK
Port_90019_2 | SOURCEANDSINK
Port_90021_1 | SOURCEANDSINK
Port_90021_2 | SOURCEANDSINK
Port_90023_1 | SOURCEANDSINK
Port_90023_2 | SOURCEANDSINK
Port_90025_1 | SOURCEANDSINK
Port_90025_2 | SOURCEANDSINK
Port_90045_1 | SOURCEANDSINK
Port_90045_2 | SOURCEANDSINK
Port_90047_1 | SOURCEANDSINK
Port_90047_2 | SOURCEANDSINK
Port_90049_1 | SOURCEANDSINK
Port_90049_2 | SOURCEANDSINK
Port_90051_1 | SOURCEANDSINK
Port_90051_2 | SOURCEANDSINK
Port_90145_1 | SOURCEANDSINK
Port_90145_2 | SOURCEANDSINK
Port_90147_1 | SOURCEANDSINK
Port_90147_2 | SOURCEANDSINK
Port_90149_1 | SOURCEANDSINK
Port_90149_2 | SOURCEANDSINK
Port_90151_1 | SOURCEANDSINK
Port_90151_2 | SOURCEANDSINK
Port_90308_1 | SOURCEANDSINK
Port_90308_2 | SOURCEANDSINK
Port_90405_1 | SOURCEANDSINK
Port_90405_2 | SOURCEANDSINK
Port_90706_1 | SOURCEANDSINK
Port_90706_2 | SOURCEANDSINK
Port_90708_1 | SOURCEANDSINK
Port_90708_2 | SOURCEANDSINK
Port_91279_1 | SOURCEANDSINK
Port_91279_2 | SOURCEANDSINK
Port_91279_3 | SOURCEANDSINK
Port_91683_1 | SOURCEANDSINK
Port_91683_2 | SOURCEANDSINK
Port_91683_3 | SOURCEANDSINK
Port_91739_1 | SOURCEANDSINK
Port_91739_2 | SOURCEANDSINK
Port_91739_3 | SOURCEANDSINK
Port_91741_1 | SOURCEANDSINK
Port_91741_2 | SOURCEANDSINK
Port_91741_3 | SOURCEANDSINK
Port_91794_1 | SOURCEANDSINK
Port_91794_2 | SOURCEANDSINK
Port_91794_3 | SOURCEANDSINK
Port_91796_1 | SOURCEANDSINK
Port_91796_2 | SOURCEANDSINK
Port_91796_3 | SOURCEANDSINK
Port_91827_1 | SOURCEANDSINK
Port_91827_2 | SOURCEANDSINK
Port_91827_3 | SOURCEANDSINK
Port_91897_1 | SOURCEANDSINK
Port_91897_2 | SOURCEANDSINK
Port_91897_3 | SOURCEANDSINK
Port_91899_1 | SOURCEANDSINK
Port_91899_2 | SOURCEANDSINK
Port_91899_3 | SOURCEANDSINK
Port_91901_1 | SOURCEANDSINK
Port_91901_2 | SOURCEANDSINK
Port_91901_3 | SOURCEANDSINK
Port_92084_1 | SOURCEANDSINK
Port_92084_2 | SOURCEANDSINK
Port_92084_3 | SOURCEANDSINK
Port_92086_1 | SOURCEANDSINK
Port_92086_2 | SOURCEANDSINK
Port_92086_3 | SOURCEANDSINK
Port_92204_1 | SOURCEANDSINK
Port_92204_2 | SOURCEANDSINK
Port_92204_3 | SOURCEANDSINK
Port_92206_1 | SOURCEANDSINK
Port_92206_2 | SOURCEANDSINK
Port_92206_3 | SOURCEANDSINK
Port_92208_1 | SOURCEANDSINK
Port_92208_2 | SOURCEANDSINK
Port_92208_3 | SOURCEANDSINK
Port_92210_1 | SOURCEANDSINK
Port_92210_2 | SOURCEANDSINK
Port_92210_3 | SOURCEANDSINK
Port_92247_1 | SOURCEANDSINK
Port_92247_2 | SOURCEANDSINK
Port_92247_3 | SOURCEANDSINK
Port_92290_1 | SOURCEANDSINK
Port_92290_2 | SOURCEANDSINK
Port_92290_3 | SOURCEANDSINK
Port_92621_1 | SOURCEANDSINK
Port_92621_2 | SOURCEANDSINK
Port_92621_3 | SOURCEANDSINK
Port_92655_1 | SOURCEANDSINK
Port_92655_2 | SOURCEANDSINK
Port_92655_3 | SOURCEANDSINK
Port_92741_1 | SOURCEANDSINK
Port_92741_2 | SOURCEANDSINK
Port_92741_3 | SOURCEANDSINK
Port_92809_1 | SOURCEANDSINK
Port_92809_2 | SOURCEANDSINK
Port_92809_3 | SOURCEANDSINK
Port_92949_1 | SOURCEANDSINK
Port_92949_2 | SOURCEANDSINK
Port_92949_3 | SOURCEANDSINK
Port_92984_1 | SOURCEANDSINK
Port_92984_2 | SOURCEANDSINK
Port_92984_3 | SOURCEANDSINK
Port_92993_1 | SOURCEANDSINK
Port_92993_2 | SOURCEANDSINK
Port_92993_3 | SOURCEANDSINK
Port_93120_1 | SOURCEANDSINK
Port_93120_2 | SOURCEANDSINK
Port_93120_3 | SOURCEANDSINK
Port_93402_1 | SOURCEANDSINK
Port_93402_2 | SOURCEANDSINK
Port_93402_3 | SOURCEANDSINK
Port_93404_1 | SOURCEANDSINK
Port_93404_2 | SOURCEANDSINK
Port_93404_3 | SOURCEANDSINK
Port_93433_1 | SOURCEANDSINK
Port_93433_2 | SOURCEANDSINK
Port_93433_3 | SOURCEANDSINK
Port_93435_1 | SOURCEANDSINK
Port_93435_2 | SOURCEANDSINK
Port_93435_3 | SOURCEANDSINK
Port_93482_1 | SOURCEANDSINK
Port_93482_2 | SOURCEANDSINK
Port_93482_3 | SOURCEANDSINK
Port_93484_1 | SOURCEANDSINK
Port_93484_2 | SOURCEANDSINK
Port_93484_3 | SOURCEANDSINK
Port_93511_1 | SOURCEANDSINK
Port_93511_2 | SOURCEANDSINK
Port_93511_3 | SOURCEANDSINK
Port_93513_1 | SOURCEANDSINK
Port_93513_2 | SOURCEANDSINK
Port_93513_3 | SOURCEANDSINK
Port_94625_1 | SOURCEANDSINK
Port_94625_2 | SOURCEANDSINK
Port_94625_3 | SOURCEANDSINK
Port_96953_1 | SOURCEANDSINK
Port_96953_2 | SOURCEANDSINK
Port_96953_3 | SOURCEANDSINK
Port_97039_1 | SOURCEANDSINK
Port_97039_2 | SOURCEANDSINK
Port_97039_3 | SOURCEANDSINK
Port_97041_1 | SOURCEANDSINK
Port_97041_2 | SOURCEANDSINK
Port_97041_3 | SOURCEANDSINK
Port_97093_1 | SOURCEANDSINK
Port_97093_2 | SOURCEANDSINK
Port_97093_3 | SOURCEANDSINK
Port_97095_1 | SOURCEANDSINK
Port_97095_2 | SOURCEANDSINK
Port_97095_3 | SOURCEANDSINK
Port_97527_1 | SOURCEANDSINK
Port_97527_2 | SOURCEANDSINK
Port_98023_1 | SOURCEANDSINK
Port_98023_2 | SOURCEANDSINK
Port_101830_1 | SOURCEANDSINK
Port_101830_2 | SOURCEANDSINK
Port_101832_1 | SOURCEANDSINK
Port_101832_2 | SOURCEANDSINK
Port_101841_1 | SOURCEANDSINK
Port_101841_2 | SOURCEANDSINK
Port_101843_1 | SOURCEANDSINK
Port_101843_2 | SOURCEANDSINK
Port_101854_1 | SOURCEANDSINK
Port_101854_2 | SOURCEANDSINK
Port_101856_1 | SOURCEANDSINK
Port_101856_2 | SOURCEANDSINK
Port_101865_1 | SOURCEANDSINK
Port_101865_2 | SOURCEANDSINK
Port_101867_1 | SOURCEANDSINK
Port_101867_2 | SOURCEANDSINK
Port_101876_1 | SOURCEANDSINK
Port_101876_2 | SOURCEANDSINK
Port_101878_1 | SOURCEANDSINK
Port_101878_2 | SOURCEANDSINK
Port_101887_1 | SOURCEANDSINK
Port_101887_2 | SOURCEANDSINK
Port_101889_1 | SOURCEANDSINK
Port_101889_2 | SOURCEANDSINK
Port_101900_1 | SOURCEANDSINK
Port_101900_2 | SOURCEANDSINK
Port_101902_1 | SOURCEANDSINK
Port_101902_2 | SOURCEANDSINK
Port_101911_1 | SOURCEANDSINK
Port_101911_2 | SOURCEANDSINK
Port_101913_1 | SOURCEANDSINK
Port_101913_2 | SOURCEANDSINK
Port_102087_1 | SOURCEANDSINK
Port_102087_2 | SOURCEANDSINK
Port_102613_1 | SOURCEANDSINK
Port_102613_2 | SOURCEANDSINK
Port_102624_1 | SOURCEANDSINK
Port_102624_2 | SOURCEANDSINK
Port_102635_1 | SOURCEANDSINK
Port_102635_2 | SOURCEANDSINK
Port_102780_1 | SOURCEANDSINK
Port_102780_2 | SOURCEANDSINK
Port_105744_1 | SOURCEANDSINK
Port_105744_2 | SOURCEANDSINK
Port_105875_1 | SOURCEANDSINK
Port_105875_2 | SOURCEANDSINK
Port_105918_1 | SOURCEANDSINK
Port_105918_2 | SOURCEANDSINK
Port_105978_1 | SOURCEANDSINK
Port_105978_2 | SOURCEANDSINK
Port_106121_1 | SOURCEANDSINK
Port_106121_2 | SOURCEANDSINK
Port_106178_1 | SOURCEANDSINK
Port_106178_2 | SOURCEANDSINK
Port_106253_1 | SOURCEANDSINK
Port_106253_2 | SOURCEANDSINK
Port_106299_1 | SOURCEANDSINK
Port_106299_2 | SOURCEANDSINK
Port_106347_1 | SOURCEANDSINK
Port_106347_2 | SOURCEANDSINK
Port_106463_1 | SOURCEANDSINK
Port_106463_2 | SOURCEANDSINK
Port_106513_1 | SOURCEANDSINK
Port_106513_2 | SOURCEANDSINK
Port_106555_1 | SOURCEANDSINK
Port_106555_2 | SOURCEANDSINK
Port_106605_1 | SOURCEANDSINK
Port_106605_2 | SOURCEANDSINK
Port_106896_1 | SOURCEANDSINK
Port_106896_2 | SOURCEANDSINK
Port_107283_1 | SOURCEANDSINK
Port_107283_2 | SOURCEANDSINK
Port_107296_1 | SOURCEANDSINK
Port_107296_2 | SOURCEANDSINK
Port_107307_1 | SOURCEANDSINK
Port_107307_2 | SOURCEANDSINK
Port_107390_1 | SOURCEANDSINK
Port_107390_2 | SOURCEANDSINK
Port_107510_1 | SOURCEANDSINK
Port_107510_2 | SOURCEANDSINK
Port_107547_1 | SOURCEANDSINK
Port_107547_2 | SOURCEANDSINK
Port_107612_2 | SOURCEANDSINK
Port_107612_3 | SOURCEANDSINK
Port_108063_2 | SOURCEANDSINK
Port_108063_3 | SOURCEANDSINK
Port_108074_2 | SOURCEANDSINK
Port_108074_3 | SOURCEANDSINK
Port_108089_2 | SOURCEANDSINK
Port_108089_3 | SOURCEANDSINK
Port_108120_2 | SOURCEANDSINK
Port_108120_3 | SOURCEANDSINK
Port_108131_2 | SOURCEANDSINK
Port_108131_3 | SOURCEANDSINK
Port_108414_1 | SOURCEANDSINK
Port_108682_1 | SOURCEANDSINK
Port_108693_1 | SOURCEANDSINK
Port_108704_1 | SOURCEANDSINK
Port_108715_1 | SOURCEANDSINK
Port_108726_1 | SOURCEANDSINK
Port_108737_1 | SOURCEANDSINK
Port_108748_1 | SOURCEANDSINK
Port_108759_1 | SOURCEANDSINK
Port_108956_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 1
Port_108956_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 1
Port_109087_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 2
Port_109087_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 2
Port_109198_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 3
Port_109198_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 3
Port_109330_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 4
Port_109330_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 4
Port_109444_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 5
Port_109444_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 5
Port_109590_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 6
Port_109590_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 6
Port_109593_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 7
Port_109593_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 7
Port_109595_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 8
Port_109595_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 8
Port_109597_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 9
Port_109597_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 9
Port_109599_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 10
Port_109599_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 10
Port_109634_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 11
Port_109634_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 11
Port_109806_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 12
Port_109806_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 12
Port_109809_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 13
Port_109809_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 13
Port_109811_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 14
Port_109811_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 14
Port_109813_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 15
Port_109813_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 15
Port_109815_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 16
Port_109815_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 16
Port_109817_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 17
Port_109817_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 17
Port_109906_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 18
Port_109906_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 18
Port_110130_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 19
Port_110130_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 19
Port_110133_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 20
Port_110133_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 20
Port_110135_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 21
Port_110135_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 21
Port_110137_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 22
Port_110137_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 22
Port_110139_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 23
Port_110139_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 23
Port_110141_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 24
Port_110141_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 24
Port_110143_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 25
Port_110143_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 25
Port_110219_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 26
Port_110219_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 26
Port_110222_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 27
Port_110222_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 27
Port_110224_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 28
Port_110224_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 28
Port_110226_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 29
Port_110226_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 29
Port_110228_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 30
Port_110228_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 30
Port_110230_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 31
Port_110230_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 31
Port_110232_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 32
Port_110232_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 32
Port_110306_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 33
Port_110306_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 33
Port_110457_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 34
Port_110457_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 34
Port_110460_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 35
Port_110460_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 35
Port_110462_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 36
Port_110462_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 36
Port_110464_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 37
Port_110464_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 37
Port_110466_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 38
Port_110466_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 38
Port_110468_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 39
Port_110468_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 39
Port_110470_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 40
Port_110470_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 40
Port_110599_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 41
Port_110599_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 41
Port_110602_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 42
Port_110602_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 42
Port_110604_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 43
Port_110604_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 43
Port_110606_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 44
Port_110606_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 44
Port_110608_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 45
Port_110608_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 45
Port_110610_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 46
Port_110610_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 46
Port_110710_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 47
Port_110710_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 47
Port_110712_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 48
Port_110712_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 48
Port_110714_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 49
Port_110714_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 49
Port_110716_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 50
Port_110716_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 50
Port_110821_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 51
Port_110821_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 51
Port_110905_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 52
Port_110905_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 52
Port_110907_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 53
Port_110907_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 53
Port_110909_0 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 54
Port_110909_1 | SOURCEANDSINK | SystemType: SEWAGE; Group: Sanitary 54
InPort_129554_1 | SINK
OutPort_129554_2 | SOURCE
Port_129649_1 | SOURCEANDSINK
Port_129649_2 | SOURCEANDSINK
Port_129649_3 | SOURCEANDSINK
Port_129649_4 | SOURCEANDSINK
Port_129769_1 | SOURCEANDSINK
Port_129769_2 | SOURCEANDSINK
Port_129769_3 | SOURCEANDSINK
Port_129769_4 | SOURCEANDSINK
Port_129851_1 | SOURCEANDSINK
Port_129851_2 | SOURCEANDSINK
Port_129851_3 | SOURCEANDSINK
Port_129851_4 | SOURCEANDSINK
Port_129855_1 | SOURCEANDSINK
Port_129855_2 | SOURCEANDSINK
Port_129855_3 | SOURCEANDSINK
Port_129855_4 | SOURCEANDSINK
Port_137823_1 | SOURCEANDSINK
Port_137823_2 | SOURCEANDSINK
Port_137823_3 | SOURCEANDSINK
Port_137823_4 | SOURCEANDSINK
Port_138089_1 | SOURCEANDSINK
Port_138089_2 | SOURCEANDSINK
Port_138089_3 | SOURCEANDSINK
Port_138089_4 | SOURCEANDSINK
Port_138237_1 | SOURCEANDSINK
Port_138237_2 | SOURCEANDSINK
Port_138237_3 | SOURCEANDSINK
Port_138237_4 | SOURCEANDSINK
Port_142548_1 | SOURCEANDSINK
Port_142548_2 | SOURCEANDSINK
Port_142548_3 | SOURCEANDSINK
Port_142548_4 | SOURCEANDSINK
Port_142684_1 | SOURCEANDSINK
Port_142684_2 | SOURCEANDSINK
Port_142684_3 | SOURCEANDSINK
Port_142684_4 | SOURCEANDSINK
Port_142782_1 | SOURCEANDSINK
Port_142782_2 | SOURCEANDSINK
Port_142782_3 | SOURCEANDSINK
Port_142782_4 | SOURCEANDSINK
Port_142791_1 | SOURCEANDSINK
Port_142791_2 | SOURCEANDSINK
Port_142791_3 | SOURCEANDSINK
Port_142791_4 | SOURCEANDSINK
Port_142796_1 | SOURCEANDSINK
Port_142796_2 | SOURCEANDSINK
Port_142796_3 | SOURCEANDSINK
Port_142796_4 | SOURCEANDSINK
Port_143000_1 | SOURCEANDSINK
Port_143000_2 | SOURCEANDSINK
Port_143000_3 | SOURCEANDSINK
Port_143019_2 | SOURCEANDSINK
Port_143019_3 | SOURCEANDSINK
Port_143019_4 | SOURCEANDSINK
Port_143019_5 | SOURCEANDSINK
Port_143095_2 | SOURCEANDSINK
Port_143095_3 | SOURCEANDSINK
Port_143095_4 | SOURCEANDSINK
Port_143095_5 | SOURCEANDSINK
Port_150136_1 | SOURCEANDSINK
Port_150136_2 | SOURCEANDSINK
Port_150136_3 | SOURCEANDSINK
Port_150221_1 | SOURCEANDSINK
Port_150221_2 | SOURCEANDSINK
Port_150221_3 | SOURCEANDSINK
Port_150221_4 | SOURCEANDSINK
Port_158509_1 | SOURCEANDSINK
Port_158509_2 | SOURCEANDSINK
Port_158509_3 | SOURCEANDSINK
Port_158509_4 | SOURCEANDSINK
Port_162739_1 | SOURCEANDSINK
Port_162739_2 | SOURCEANDSINK
Port_162739_3 | SOURCEANDSINK
Port_162739_4 | SOURCEANDSINK
Port_166983_1 | SOURCEANDSINK
Port_166983_2 | SOURCEANDSINK
Port_166983_3 | SOURCEANDSINK
Port_166983_4 | SOURCEANDSINK
Port_167199_1 | SOURCEANDSINK
Port_167199_2 | SOURCEANDSINK
Port_167199_3 | SOURCEANDSINK
Port_167199_4 | SOURCEANDSINK
Port_167583_1 | SOURCEANDSINK
Port_167583_2 | SOURCEANDSINK
Port_167583_3 | SOURCEANDSINK
Port_167583_4 | SOURCEANDSINK
Port_177207_1 | SOURCEANDSINK
Port_177207_2 | SOURCEANDSINK
Port_177209_1 | SOURCEANDSINK
Port_177209_2 | SOURCEANDSINK
Port_177216_1 | SOURCEANDSINK
Port_177216_2 | SOURCEANDSINK
Port_177218_1 | SOURCEANDSINK
Port_177218_2 | SOURCEANDSINK
Port_177225_1 | SOURCEANDSINK
Port_177225_2 | SOURCEANDSINK
Port_177227_1 | SOURCEANDSINK
Port_177227_2 | SOURCEANDSINK
Port_177234_1 | SOURCEANDSINK
Port_177234_2 | SOURCEANDSINK
Port_177236_1 | SOURCEANDSINK
Port_177236_2 | SOURCEANDSINK
Port_177243_1 | SOURCEANDSINK
Port_177243_2 | SOURCEANDSINK
Port_177245_1 | SOURCEANDSINK
Port_177245_2 | SOURCEANDSINK
Port_177252_1 | SOURCEANDSINK
Port_177252_2 | SOURCEANDSINK
Port_177254_1 | SOURCEANDSINK
Port_177254_2 | SOURCEANDSINK
Port_177261_1 | SOURCEANDSINK
Port_177261_2 | SOURCEANDSINK
Port_177263_1 | SOURCEANDSINK
Port_177263_2 | SOURCEANDSINK
Port_177270_1 | SOURCEANDSINK
Port_177270_2 | SOURCEANDSINK
Port_177272_1 | SOURCEANDSINK
Port_177272_2 | SOURCEANDSINK
Port_177279_1 | SOURCEANDSINK
Port_177279_2 | SOURCEANDSINK
Port_177281_1 | SOURCEANDSINK
Port_177281_2 | SOURCEANDSINK
OutPort_204731_2 | SOURCE
InPort_204731_3 | SINK
OutPort_205069_2 | SOURCE
InPort_205069_3 | SINK
OutPort_205078_2 | SOURCE
InPort_205078_3 | SINK
OutPort_205289_2 | SOURCE
InPort_205289_3 | SINK
OutPort_205291_2 | SOURCE
InPort_205291_3 | SINK
OutPort_205293_2 | SOURCE
InPort_205293_3 | SINK
Port_218989_1 | SOURCEANDSINK | SystemType: SEWAGE
Port_218989_2 | SOURCEANDSINK | SystemType: SEWAGE
Port_221856_1 | SOURCEANDSINK | SystemType: SEWAGE
Port_221856_2 | SOURCEANDSINK | SystemType: SEWAGE
InPort_244765_1 | SINK | SystemType: SEWAGE
OutPort_244765_8 | SOURCE | SystemType: SEWAGE
InPort_244765_9 | SINK | SystemType: SEWAGE
InPort_244765_10 | SINK | SystemType: SEWAGE
InPort_244765_11 | SINK | SystemType: SEWAGE

# IfcDistributionSystem: Sanitary (54)
PredefinedType: SEWAGE
Pset_DistributionSystemCommon - Reference: Piping System:Sanitary
Name
Sanitary 1
Sanitary 2
Sanitary 3
Sanitary 4
Sanitary 5
Sanitary 6
Sanitary 7
Sanitary 8
Sanitary 9
Sanitary 10
Sanitary 11
Sanitary 12
Sanitary 13
Sanitary 14
Sanitary 15
Sanitary 16
Sanitary 17
Sanitary 18
Sanitary 19
Sanitary 20
Sanitary 21
Sanitary 22
Sanitary 23
Sanitary 24
Sanitary 25
Sanitary 26
Sanitary 27
Sanitary 28
Sanitary 29
Sanitary 30
Sanitary 31
Sanitary 32
Sanitary 33
Sanitary 34
Sanitary 35
Sanitary 36
Sanitary 37
Sanitary 38
Sanitary 39
Sanitary 40
Sanitary 41
Sanitary 42
Sanitary 43
Sanitary 44
Sanitary 45
Sanitary 46
Sanitary 47
Sanitary 48
Sanitary 49
Sanitary 50
Sanitary 51
Sanitary 52
Sanitary 53
Sanitary 54

# IfcFlowTerminal: RAUPIANO PLUS Floor Waste Gully:RPP, RAUPIANO PLUS Floor Waste Gully:RPP:244765
In: Ground floor
Type - Material: RAUPIANO PLUS
Type - Other - Category: Plumbing Fixtures; Family Name: RAUPIANO PLUS Floor Waste Gully; T1: RP Floor Waste Gully; T2: RP Floor Waste Gully DN1; T3: RP Pipe Size
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Classification Number: 23.70.50.21.24; Manufacturer: REHAU; Model: RAUPIANO PLUS; REHAU Info: 2024.08.16-419114-419114; Type Name: RPP; URL: www.rehau.com
Type - Materials and Finishes - REH_MATERIAL: RAUPIANO PLUS
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Description: RAUPIANO PLUS Flooe gully
Pset_EnvironmentalImpactIndicators - Reference: RAUPIANO PLUS Floor Waste Gully:RPP
Other - IsCustom: no; Type: RPP; Family: RAUPIANO PLUS Floor Waste Gully; Family and Type: RAUPIANO PLUS Floor Waste Gully: RPP; Type Id: 244734
Constraints - Elevation from Level: 0 mm; Level: Ground floor; Host: Level : Ground floor; Offset from Host: 0 mm
Construction - REH_PIPE_SOCKET: yes; Nominal Diameter 1: 110 mm; Nominal Diameter 2: 110 mm; Nominal Diameter 3: 50 mm; Nominal Diameter 4: 50 mm; Nominal Diameter 5: 50 mm; Nominal Diameter 6: 75 mm; REH_SIDE_INLETS_TYPE: RAUPIANO PLUS Floor Waste Gully_Side Inlets : RPP
Data - PID Check: 0 mm
Dimensions - Angle: 47.5 deg; DN1: 110 mm; DN2: 110 mm; DN3: 50 mm; DN4: 50 mm; DN5: 50 mm; DN6: 75 mm; Do2: 110.2 mm; Dr1: 127.4 mm; Dr3: 64 mm; Dr4: 64 mm; j1: 3.6 mm; j3: 3.4 mm; j4: 3.4 mm; L1: 91.5 mm; L2: 20 mm; L3: 112.8 mm; L4: 112.8 mm; L5: 112.8 mm; L6: 187.87 mm; L7: 133.5 mm; P1: 57.31 mm; P3: 43.5 mm; P4: 43.5 mm; P5: 43.5 mm; P6: 54.5 mm; t1: 13.9 mm; t3: 11 mm; t4: 11 mm; Volume: 0.000398631 m3; Z1: 34.19 mm; Z2: 34.19 mm; Z3: 69.3 mm; Z4: 69.3 mm; Z5: 69.3 mm; Z6: 133.37 mm
Identity Data - Sorting: 0; ETIM Class code: EC010568; Mark: 6; PID: 108971; Weight: 0
Mechanical - System Classification: Sanitary
Phasing - Phase Created: New Construction

# IfcPipeFitting: RAUPIANO PLUS Bend:RPP (64)
In: Ground floor
Type - Material: RAUPIANO PLUS
Type - Other - Category: Pipe Fittings; Family Name: RAUPIANO PLUS Bend; T1: RP Bend; T2: RPP
Type - Constraints - Default Elevation: 0 mm
Type - Data - Language: Description EN; Region Check: Check DE; Region PID: PID DE
Type - Identity Data - Assembly Code: D2030100; Classification Number: 23.60.30.11.14; ETIM Class code: EC003024; Manufacturer: REHAU; Model: RAUPIANO PLUS; Type Name: RPP; URL: https://oxomi.com/p/3000126?oxDeeplink=ewAiAHUAbgBpAHYAZQByAHMAYQBsAFMAZQBhAHIAYwBoAHwAMgAiADoAewAiAHYAaQBlAHcAIgA6ACIAZgBpAGwAdABlAHIAZQBkACIALAAiAGYAaQBsAHQAZQByAHMAIgA6AHsAfQAsACIAcQB1AGUAcgB5ACIAOgAiAFIAQQBVAFAASQBBAE4ATwAgAFAATABVAFMAIgAsACIAaABpAGQAZABlAG4ARgBpAGwAdABlAHIAcwAiADoAewAiAGIAcgBhAG4AZAAiADoAWwAiAFIASwBIAEwAUQAxAFMAUgBBAFYARABOAFEARwBHAEQAUABLADIAUQBBAEEAMABHADIATwAiAF0AfQB9ACwAIgBvAHYAZQByAGwAYQB5ACIAOgB7ACIAdAB5AHAAZQAiADoAIgBvAHAAZQBuAEQAbwBjAHUAbQBlAG4AdAAiACwAIgBhAHIAZwBzACIAOgB7ACIAZABvAGMAdQBtAGUAbgB0ACIAOgAiADEAMAA0ADUAMwA1ADMAMAAiACwAIgBxAHUAZQByAHkAIgA6ACIAUgBBAFUAUABJAEEATgBPACAAUABMAFUAUwAiACwAIgBzAGkAbgBnAGwAZQBQAGEAZwBlACIAOgB0AHIAdQBlACwAIgBlAHgAdABlAHIAbgBhAGwATABpAG4AawBzAEUAbgBhAGIAbABlAGQAIgA6AHQAcgB1AGUALAAiAHAAYQBnAGUAIgA6ADEAfQB9AH0A
Type - Materials and Finishes - RPP: RAUPIANO PLUS
Type - Pset_ManufacturerTypeInformation - Manufacturer: REHAU
Classification: D2030100 (Uniformat)
Pset_EnvironmentalImpactIndicators - Reference: RAUPIANO PLUS Bend:RPP; sets with these values: 2
Other - Family: RAUPIANO PLUS Bend; Family and Type: RAUPIANO PLUS Bend: RPP; Flip: no; IsCustom: no; Not Flip: yes; Type: RPP; Type Id: 5591; V. Sleeve 2: no
Constraints - Elevation from Level: 0 mm; Level: Ground floor
Data - PID Check: 1 mm
Dimensions - Area: 0.00515621 m2
Identity Data - Sorting: 0
Mechanical - System Classification: Undefined
Phasing - Phase Created: New Construction
Insulation - Insulation Thickness: 0 mm
Name (RAUPIANO PLUS Bend:RPP:...) | Sleeve = V. Sleeve 1 | Swept bend | Angle check (deg) = Angle (deg) | L1 (mm) | L connector 1 (mm) | L connector 2 (mm) = Z1 (mm) | Swept | Z2 (mm) | DN 1 (mm) = Maximum Size (mm) = Minimum Size (mm) | Size = Overall Size | Volume (m3) | Use Annotation Scale | Description long | Description short | GTIN | PID | Weight
89192 | yes | no | 15 | 42 | 44.633 | 2.63305 | 0 | 20 | 32 | 32 mmø-32 mmø | 0.0000251222 | no | RAUPIANO PLUS Bend DN/OD 32, 15 degree | DN 32/ 15° | 4059757619887 | 11326001001 | 33
89504 | yes | no | 30 | 42 | 47.359 | 5.35898 | 0 | 20 | 32 | 32 mmø-32 mmø | 0.0000260163 | no | RAUPIANO PLUS Bend DN/OD 32, 30 degree | DN 32/ 30° | 4059757619894 | 11326031001 | 33
89579 | yes | no | 45 | 42 | 50.2843 | 8.28427 | 0 | 20 | 32 | 32 mmø-32 mmø | 0.0000269105 | no | RAUPIANO PLUS Bend DN/OD 32, 45 degree | DN 32/ 45° | 4059757620005 | 11326041001 | 34
89651 | yes | no | 87 | 42 | 60.9793 | 18.9793 | 0 | 20 | 32 | 32 mmø-32 mmø | 0.0000294141 | no | RAUPIANO PLUS Bend DN/OD 32, 87 degree | DN 32/ 87° | 4059757620012 | 11326061001 | 40
89713 | yes | no | 15 | 44 | 47.1597 | 3.15966 | 0 | 24 | 40 | 40 mmø-40 mmø | 0.0000366331 | no | RAUPIANO PLUS Bend DN/OD 40, 15 degree | DN 40/15° | 4007360296582 | 11230641001 | 38.5
89715 | yes | no | 30 | 44 | 50.4308 | 6.43078 | 0 | 24 | 40 | 40 mmø-40 mmø | 0.0000379903 | no | RAUPIANO PLUS Bend DN/OD 40, 30 degree | DN 40/30° | 4007360296599 | 11230741001 | 32.5
89717 | yes | no | 45 | 44 | 53.9411 | 9.94113 | 0 | 24 | 40 | 40 mmø-40 mmø | 0.0000393475 | no | RAUPIANO PLUS Bend DN/OD 40, 45 degree | DN 40/45° | 4059757976720 | 11230841002 | 61.7
89719 | yes | no | 87 | 44 | 66.7751 | 22.7751 | 0 | 24 | 40 | 40 mmø-40 mmø | 0.0000431478 | no | RAUPIANO PLUS Bend DN/OD 40, 87 degree | DN 40/87° | 4007360296612 | 11230941001 | 41.5
89750 | yes | no | 67 | 44 | 59.8853 | 15.8853 | 0 | 24 | 40 | 40 mmø-40 mmø | 0.0000413381 | no | RAUPIANO PLUS Bend DN/OD 40, 67 degree | DN 40/67° | 4007360560362 | 11240871001 | 55
89836 | yes | no | 15 | 46 | 49.8179 | 3.81792 | 0 | 29 | 50 | 50 mmø-50 mmø | 0.0000495452 | no | RAUPIANO PLUS Bend DN/OD 50, 15 degree | DN 50/15° | 4064299607704 | 11210941003 | 76.5
89838 | yes | no | 30 | 46 | 53.7705 | 7.77053 | 0 | 29 | 50 | 50 mmø-50 mmø | 0.0000516145 | no | RAUPIANO PLUS Bend DN/OD 50, 30 degree | DN 50/30° | 4064299607711 | 11211041003 | 74.5
89840 | yes | no | 45 | 46 | 58.0122 | 12.0122 | 0 | 29 | 50 | 50 mmø-50 mmø | 0.0000536838 | no | RAUPIANO PLUS Bend DN/OD 50, 45 degree | DN 50/45° | 4064299607728 | 11211141003 | 80.11
89842 | yes | no | 87 | 46 | 73.52 | 27.52 | 0 | 29 | 50 | 50 mmø-50 mmø | 0.0000594779 | no | RAUPIANO PLUS Bend DN/OD 50, 87 degree | DN 50/87° | 4064299607742 | 11211341003 | 92.1
89844 | yes | no | 67 | 46 | 65.1947 | 19.1947 | 0 | 29 | 50 | 50 mmø-50 mmø | 0.0000567188 | no | RAUPIANO PLUS Bend DN/OD 50, 67 degree | DN 50/67° | 4064299607735 | 11211241003 | 87
89892 | yes | no | 15 | 51 | 56.4636 | 5.46358 | 0 | 41.5 | 75 | 75 mmø-75 mmø | 0.0000852709 | no | RAUPIANO PLUS Bend DN/OD 75, 15 degree | DN 75/15° | 4064299198585 | 11211441002 | 129.6
89894 | yes | no | 30 | 51 | 62.1199 | 11.1199 | 0 | 41.5 | 75 | 75 mmø-75 mmø | 0.0000900114 | no | RAUPIANO PLUS Bend DN/OD 75, 30 degree | DN 75/30° | 4064299198592 | 11211541002 | 135.1
89896 | yes | no | 45 | 51 | 68.1899 | 17.1899 | 0 | 41.5 | 75 | 75 mmø-75 mmø | 0.0000947519 | no | RAUPIANO PLUS Bend DN/OD 75, 45 degree | DN 75/45° | 4059757975990 | 11211641002 | 142
89898 | yes | no | 87 | 51 | 90.382 | 39.382 | 0 | 41.5 | 75 | 75 mmø-75 mmø | 0.000108025 | no | RAUPIANO PLUS Bend DN/OD 75, 87 degree | DN 75/87° | 4062178664589 | 11211841002 | 171.78
89900 | yes | no | 67 | 51 | 78.4683 | 27.4683 | 0 | 41.5 | 75 | 75 mmø-75 mmø | 0.000101705 | no | RAUPIANO PLUS Bend DN/OD 75, 67 degree | DN 75/67° | 4064299443760 | 11211741002 | 159.9
89948 | yes | no | 15 | 54 | 60.451 | 6.45097 | 0 | 49 | 90 | 90 mmø-90 mmø | 0.000124253 | no | RAUPIANO PLUS Bend DN/OD 90, 15 degree, thickened wall | DN 90/15° | 4064299674423 | 11233841002 | 163.4
89950 | yes | no | 30 | 54 | 67.1295 | 13.1295 | 0 | 49 | 90 | 90 mmø-90 mmø | 0.000132037 | no | RAUPIANO PLUS Bend DN/OD 90, 30 degree, thickened wall | DN 90/30° | 4064299674430 | 11233941002 | 195.3
89952 | yes | no | 45 | 54 | 74.2965 | 20.2965 | 0 | 49 | 90 | 90 mmø-90 mmø | 0.000139822 | no | RAUPIANO PLUS Bend DN/OD 90, 45 degree, thickened wall | DN 90/45° | 4064299692342 | 11234041002 | 209
89954 | yes | no | 87 | 54 | 100.499 | 46.4993 | 0 | 49 | 90 | 90 mmø-90 mmø | 0.000161618 | no | RAUPIANO PLUS Bend DN/OD 90, 87 degree, thickened wall | DN 90/87° | 4007360351656 | 11234141001 | 275.98
89956 | yes | no | 67 | 54 | 86.4324 | 32.4324 | 0 | 49 | 90 | 90 mmø-90 mmø | 0.000151239 | no | RAUPIANO PLUS Bend DN/OD 90, 67 degree, thickened wall | DN 90/67° | 4007360525620 | 11230781001 | 233
89975 | yes | no | 15 | 58 | 65.7675 | 7.7675 | 0 | 59 | 110 | 110 mmø-110 mmø | 0.000204657 | no | RAUPIANO PLUS Bend DN/OD 110, 15 degree, thickened wall | DN 110/15° | 4064299198547 | 11231321001 | 277.26
89977 | yes | no | 30 | 58 | 73.809 | 15.809 | 0 | 59 | 110 | 110 mmø-110 mmø | 0.000218715 | no | RAUPIANO PLUS Bend DN/OD 110, 30 degree, thickened wall | DN 110/30° | 4064299198530 | 11231351001 | 306.33
89979 | yes | no | 45 | 58 | 82.4386 | 24.4386 | 0 | 59 | 110 | 110 mmø-110 mmø | 0.000232773 | no | RAUPIANO PLUS Bend DN/OD 110, 45 degree, thickened wall | DN 110/45° | 4064299198523 | 11231361001 | 347.68
89981 | yes | no | 87 | 58 | 113.989 | 55.9889 | 0 | 59 | 110 | 110 mmø-110 mmø | 0.000272135 | no | RAUPIANO PLUS Bend DN/OD 110, 87 degree, thickened wall | DN 110/87° | 4007360349523 | 11234641001 | 481.75
89983 | yes | no | 67 | 58 | 97.0512 | 39.0512 | 0 | 59 | 110 | 110 mmø-110 mmø | 0.000253391 | no | RAUPIANO PLUS Bend DN/OD 110, 67 degree, thickened wall | DN 110/67° | 4007360349516 | 11234541001 | 410
90017 | yes | no | 15 | 64 | 72.7549 | 8.75489 | 0 | 66.5 | 125 | 125 mmø-125 mmø | 0.000296357 | no | RAUPIANO PLUS Bend DN/OD 125, 15 degree, thickened wall | DN 125/15° | 4007360359102 | 11234741001 | 411
90019 | yes | no | 30 | 64 | 81.8186 | 17.8186 | 0 | 66.5 | 125 | 125 mmø-125 mmø | 0.000317025 | no | RAUPIANO PLUS Bend DN/OD 125, 30 degree, thickened wall | DN 125/30° | 4007360355562 | 11234841001 | 454
90021 | yes | no | 45 | 64 | 91.5452 | 27.5452 | 0 | 66.5 | 125 | 125 mmø-125 mmø | 0.000337692 | no | RAUPIANO PLUS Bend DN/OD 125, 45 degree, thickened wall | DN 125/45° | 4007360351663 | 11234941001 | 519.5
90023 | yes | no | 87 | 64 | 127.106 | 63.1061 | 0 | 66.5 | 125 | 125 mmø-125 mmø | 0.000395563 | no | RAUPIANO PLUS Bend DN/OD 125, 87 degree, thickened wall | DN 125/87° | 4007360360566 | 11235141001 | 630
90025 | yes | no | 67 | 64 | 108.015 | 44.0154 | 0 | 66.5 | 125 | 125 mmø-125 mmø | 0.000368005 | no | RAUPIANO PLUS Bend DN/OD 125, 67 degree, thickened wall | DN 125/67° | 4007360360542 | 11235041001 | 610
90045 | yes | no | 15 | 73 | 84.0588 | 11.0588 | 0 | 84 | 160 | 160 mmø-160 mmø | 0.000552391 | no | RAUPIANO PLUS Bend DN/OD 160, 15 degree | DN 160/15° | 4007360585136 | 11230921001 | 613
90047 | yes | no | 30 | 73 | 95.5077 | 22.5077 | 0 | 84 | 160 | 160 mmø-160 mmø | 0.000594449 | no | RAUPIANO PLUS Bend DN/OD 160, 30 degree | DN 160/30° | 4007360585143 | 11230961001 | 697
90049 | yes | no | 45 | 73 | 107.794 | 34.7939 | 0 | 84 | 160 | 160 mmø-160 mmø | 0.000636507 | no | RAUPIANO PLUS Bend DN/OD 160, 45 degree, thickened wall | DN 160/45° | 4007360434731 | 11240281001 | 855
90051 | yes | no | 87 | 73 | 152.713 | 79.713 | 0 | 84 | 160 | 160 mmø-160 mmø | 0.000754272 | no | RAUPIANO PLUS Bend DN/OD 160, 87 degree, thickened wall | DN 160/87° | 4007360434748 | 11240291001 | 1179
90145 | yes | no | 15 | 85 | 98.6919 | 13.6919 | 0 | 104 | 200 | 200 mmø-200 mmø | 0.00174242 | no | RAUPIANO PLUS Bend DN/OD 200, 15 degree | DN 200/15° | 4061264941962 | 11231251001 | 1167
90147 | yes | no | 30 | 85 | 112.867 | 27.8667 | 0 | 104 | 200 | 200 mmø-200 mmø | 0.0018452 | no | RAUPIANO PLUS Bend DN/OD 200, 30 degree | DN 200/30° | 4061264941979 | 11231261001 | 1301
90149 | yes | no | 45 | 85 | 128.078 | 43.0782 | 0 | 104 | 200 | 200 mmø-200 mmø | 0.00194797 | no | RAUPIANO PLUS Bend DN/OD 200, 45 degree | DN 200/45° | 4007360585150 | 11230971001 | 1404
90151 | yes | no | 87 | 85 | 183.692 | 98.6923 | 0 | 104 | 200 | 200 mmø-200 mmø | 0.00223574 | no | RAUPIANO PLUS Bend DN/OD 200, 87 degree | DN 200/87° | 4007360559939 | 11230891001 | 1756
90308 | yes | yes | 87 | 46 | 84.5 | 38.5 | 1 | 40.5705 | 50 | 50 mmø-50 mmø | 0.0000642665 | no | RAUPIANO PLUS Swept bend DN/OD 50, 87,5 degree | DN 50/87.5° | 4007360506926 | 11002761001 | 90
90405 | yes | yes | 87 | 51 | 107 | 56 | 1 | 59.0117 | 75 | 75 mmø-75 mmø | 0.000119627 | no | RAUPIANO PLUS Swept bend DN/OD 75, 87,5 degree | DN 75/87.5° | 4007360506933 | 11002781001 | 167.4
90706 | yes | yes | 87 | 44 | 76 | 32 | 1 | 33.721 | 40 | 40 mmø-40 mmø | 0.0000463362 | no | RAUPIANO PLUS Swept bend DN/OD 40, 87,5 degree | DN 40/87.5° | 4007360506919 | 11002551001 | 68.4
90708 | yes | yes | 87 | 58 | 134 | 76 | 1 | 80.0873 | 110 | 110 mmø-110 mmø | 0.000301277 | no | RAUPIANO PLUS Swept bend DN/OD 110, 87,5 degree, thickened wall | DN 110/87.5° | 4007360482848 | 11002591001 | 548
177207 | yes | no | 45 | 42 | 50.2843 | 8.28427 | 0 | 20 | 32 | 32 mmø-32 mmø | 0.0000269105 |  | RAUPIANO PLUS Bend DN/OD 32, 45 degree |  | 4059757620005 | 11326041001 | 34
177209 | no | no | 45 | 42 | 50.2843 | 8.28427 | 0 | 20 | 32 | 32 mmø-32 mmø | 0.0000182816 |  | RAUPIANO PLUS Bend DN/OD 32, 45 degree |  | 4059757620005 | 11326041001 | 34
177216 | yes | no | 45 | 44 | 53.9411 | 9.94113 | 0 | 24 | 40 | 40 mmø-40 mmø | 0.0000393475 |  | RAUPIANO PLUS Bend DN/OD 40, 45 degree |  | 4059757976720 | 11230841002 | 61.7
177218 | no | no | 45 | 44 | 53.9411 | 9.94113 | 0 | 24 | 40 | 40 mmø-40 mmø | 0.0000263602 |  | RAUPIANO PLUS Bend DN/OD 40, 45 degree |  | 4059757976720 | 11230841002 | 61.7
177225 | yes | no | 45 | 46 | 58.0122 | 12.0122 | 0 | 29 | 50 | 50 mmø-50 mmø | 0.0000536838 |  | RAUPIANO PLUS Bend DN/OD 50, 45 degree |  | 4064299607728 | 11211141003 | 80.11
177227 | no | no | 45 | 46 | 58.0122 | 12.0122 | 0 | 29 | 50 | 50 mmø-50 mmø | 0.0000360635 |  | RAUPIANO PLUS Bend DN/OD 50, 45 degree |  | 4064299607728 | 11211141003 | 80.11
177234 | yes | no | 45 | 51 | 68.1899 | 17.1899 | 0 | 41.5 | 75 | 75 mmø-75 mmø | 0.0000947519 |  | RAUPIANO PLUS Bend DN/OD 75, 45 degree |  | 4059757975990 | 11211641002 | 142
177236 | no | no | 45 | 51 | 68.1899 | 17.1899 | 0 | 41.5 | 75 | 75 mmø-75 mmø | 0.0000653443 |  | RAUPIANO PLUS Bend DN/OD 75, 45 degree |  | 4059757975990 | 11211641002 | 142
177243 | yes | no | 45 | 54 | 74.2965 | 20.2965 | 0 | 49 | 90 | 90 mmø-90 mmø | 0.000139822 |  | RAUPIANO PLUS Bend DN/OD 90, 45 degree, thickened wall |  | 4064299692342 | 11234041002 | 209
177245 | no | no | 45 | 54 | 74.2965 | 20.2965 | 0 | 49 | 90 | 90 mmø-90 mmø | 0.0000974793 |  | RAUPIANO PLUS Bend DN/OD 90, 45 degree, thickened wall |  | 4064299692342 | 11234041002 | 209
177252 | yes | no | 45 | 58 | 82.4386 | 24.4386 | 0 | 59 | 110 | 110 mmø-110 mmø | 0.000232773 |  | RAUPIANO PLUS Bend DN/OD 110, 45 degree, thickened wall |  | 4064299198523 | 11231361001 | 347.68
177254 | no | no | 45 | 58 | 82.4386 | 24.4386 | 0 | 59 | 110 | 110 mmø-110 mmø | 0.000162711 |  | RAUPIANO PLUS Bend DN/OD 110, 45 degree, thickened wall |  | 4064299198523 | 11231361001 | 347.68
177261 | yes | no | 45 | 64 | 91.5452 | 27.5452 | 0 | 66.5 | 125 | 125 mmø-125 mmø | 0.000337692 |  | RAUPIANO PLUS Bend DN/OD 125, 45 degree, thickened wall |  | 4007360351663 | 11234941001 | 519.5
177263 | no | no | 45 | 64 | 91.5452 | 27.5452 | 0 | 66.5 | 125 | 125 mmø-125 mmø | 0.000235934 |  | RAUPIANO PLUS Bend DN/OD 125, 45 degree, thickened wall |  | 4007360351663 | 11234941001 | 519.5
177270 | yes | no | 45 | 73 | 107.794 | 34.7939 | 0 | 84 | 160 | 160 mmø-160 mmø | 0.000636507 |  | RAUPIANO PLUS Bend DN/OD 160, 45 degree, thickened wall |  | 4007360434731 | 11240281001 | 855
177272 | no | no | 45 | 73 | 107.794 | 34.7939 | 0 | 84 | 160 | 160 mmø-160 mmø | 0.00044673 |  | RAUPIANO PLUS Bend DN/OD 160, 45 degree, thickened wall |  | 4007360434731 | 11240281001 | 855
177279 | yes | no | 45 | 85 | 128.078 | 43.0782 | 0 | 104 | 200 | 200 mmø-200 mmø | 0.00194797 |  | RAUPIANO PLUS Bend DN/OD 200, 45 degree |  | 4007360585150 | 11230971001 | 1404
